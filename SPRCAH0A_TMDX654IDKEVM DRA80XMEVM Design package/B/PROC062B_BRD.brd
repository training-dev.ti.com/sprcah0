# Allegro board PROC062B_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GNDUSB on L10_SIG3: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.36 9.3,135.76
GNDUSB on L12_SIG4: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.37 9.29,135.76
GNDUSB on L13_GND5: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.52 9.14,135.76
VCC1V1 on BOTTOM: 132.36,158.47 132.36,165.66 131.98,166.04 124.97,166.04 124.97,172.33 126.51,172.33 126.51,170.08 127.56,169.04 136.58,169.04 136.58,166.17 137.26,166.17 137.26,163.02 145.57,163.02 145.57,169.1 149.48,169.1 149.48,158.47
VCC1V1 on L12_SIG4: 146.13,157.84 132.41,157.84 132.41,167.92 136.75,167.92 136.75,163.07 145.57,163.07 145.57,164.52 149.48,164.52 149.48,158.34 146.13,158.34
VCC1V2_DDR on BOTTOM: 165.35,153.54 165.35,159.07 167.13,159.07 167.13,166.32 170.37,166.32 170.37,166.31 174.94,166.31 174.94,153.54
VCC1V8 on TOP: 184.66,69.98 184.66,66.17 190.25,66.17 190.25,69.98
VCC1V8 on TOP: 43.69,74.55 43.69,68.96 45.21,68.96 45.21,74.55
VCC1V8 on TOP: 167.39,18.8 167.39,13.34 169.1,13.34 169.1,18.8
VCC1V8 on BOTTOM: 152.65,33.4 152.65,35.17 153.36,35.88 153.36,38.16 154.18,38.16 154.18,33.4
VCC1V8 on BOTTOM: 153.67,10.29 153.67,8.38 153.29,8 153.29,4.83 154.88,4.83 154.88,7.18 154.37,7.68 154.37,10.29
VCC1V8 on BOTTOM: 34.73,58.74 34.73,63.94 36.26,63.94 36.26,65.98 39.37,65.98 39.37,58.74
VCC1V8 on L06_PWR1: 99.59,1.03 8.01,1.03 8.01,137.12 8.58,137.12 10.06,138.6 8.58,140.07 8.01,140.07 8.01,141.87 8.58,141.87 10.06,143.34 8.58,144.82 8.01,144.82 8.01,155.94 8.6,155.94 10.06,157.39 8.6,158.84 8.01,158.84 8.01,160.69 8.6,160.69 10.06,162.14 8.6,163.59 8.01,163.59 8.01,176.77 209.16,176.77 209.16,1.03 107.3,1.03 107.3,1.6 105.82,3.08 104.34,1.6 104.34,1.03 102.55,1.03 102.55,1.6 101.07,3.08 99.59,1.6 ; 10 cut-outs
VCC1V8_CLKBUFF on L08_PWR3: 65.45,103.22 65.45,91.81 78.11,91.81 78.11,103.22
VCC3V3_IO on BOTTOM (solid shape): 57.02,121.28 48.39,121.28 48.39,125.98 57.02,125.98
VCC3V3_IO on BOTTOM (solid shape): 189.99,12.48 189.61,12.48 189.61,11.28 189.33,11.28 189.33,10.34 189.99,10.34 189.99,9.35 186.46,9.35 186.46,11.35 188.06,11.35 188.06,11.53 188.19,11.53 188.19,11.92 188.52,12.25 188.52,12.57 188.44,12.82 188.23,12.96 188.19,12.97 188.19,13.03 186.82,13.03 186.82,14.63 189.99,14.63
VCC3V3_IO on TOP: 57.4,69.02 58.61,69.02 58.61,74.42 56.01,74.42 56.01,71.63 57.4,71.63
VCC3V3_IO on TOP: 116.97,66.04 116.97,53.59 118.55,53.59 118.55,66.04
VCC3V3_IO on TOP: 47.43,122.24 47.43,120.08 68.01,120.08 68.01,122.24
VCC3V3_IO on TOP: 164.53,18.86 164.53,13.21 167.07,13.21 167.07,18.86
VCC3V3_IO on TOP: 143.07,147.15 143.07,151.79 143.26,151.98 145.16,151.98 145.29,151.85 145.29,149.82 144.4,149.82 144.4,147.15
VCC3V3_IO on TOP: 136.33,64.52 136.33,53.54 137.41,53.54 137.41,64.52
VCC3V3_IO on BOTTOM: 180.72,65.15 180.72,63.37 180.85,63.25 180.85,61.71 182.75,61.71 182.75,64.75 182.35,65.15
VCC3V3_IO on BOTTOM: 166.88,54.64 168.4,54.64 168.4,53.01 168.12,53.01 168.12,51.97 169.19,51.97 169.19,51.1 166.88,51.1
VCC3V3_IO on BOTTOM: 142.14,39.85 142.14,38.18 144.58,38.18 144.58,39.85
VCC3V3_IO on BOTTOM: 166.82,38.23 166.82,35.69 167.14,35.37 167.14,33.34 168.54,33.34 168.54,34.41 168.4,34.55 168.4,35.22 168.22,35.41 168.22,38.23
VCC3V3_IO on BOTTOM: 152.4,17.91 152.4,13.21 152.21,13.21 152.21,10.67 152.65,10.22 152.65,8.95 153.35,8.95 153.35,10.86 154.05,11.56 154.05,17.91
VCC3V3_IO on BOTTOM: 118.77,114.15 118.77,110.41 111.84,110.41 111.84,113.28 114.2,113.28 115.06,114.15
VCC3V3_IO on BOTTOM: 158.43,66.48 158.43,64.77 164.34,64.77 164.34,66.48
VCC3V3_IO on L07_PWR2: 99.59,1.03 8.01,1.03 8.01,137.12 8.58,137.12 10.06,138.6 8.58,140.07 8.01,140.07 8.01,141.87 8.58,141.87 10.06,143.34 8.58,144.82 8.01,144.82 8.01,155.94 8.6,155.94 10.06,157.39 8.6,158.84 8.01,158.84 8.01,160.69 8.6,160.69 10.06,162.14 8.6,163.59 8.01,163.59 8.01,176.77 209.16,176.77 209.16,1.03 107.3,1.03 107.3,1.6 105.82,3.08 104.34,1.6 104.34,1.03 102.55,1.03 102.55,1.6 101.07,3.08 99.59,1.6 ; 14 cut-outs
VCC3V3_OLDI on BOTTOM (solid shape): 184.73,13 182.52,13 182.42,12.9 182.42,9.12 179.73,9.12 179.73,14.58 184.73,14.58
VCC3V3_OLDI on BOTTOM: 201.99,28.12 201.99,28.89 200.6,28.89 200.03,29.46 198.37,29.46 198.37,28.26 200.13,28.26 200.26,28.12
VCC3V3_PREREG on TOP: 29.46,76.86 31.37,76.86 31.43,76.92 32.77,76.92 32.77,77.72 33.02,77.98 33.02,79.52 29.46,79.52
VCC3V3_PREREG on TOP: 199.71,150.88 199.71,154.24 201.04,154.24 201.04,150.88
VCC3V3_PREREG on TOP: 195.37,158.44 195.37,157.86 194.25,157.86 194.25,156.34 196.23,156.34 196.23,157.75 196.6,158.12 196.6,158.44
VCC3V3_PREREG on TOP: 128.3,171.37 130.56,171.37 130.56,175.84 129.11,175.84 128.3,175.03
VCC3V3_PREREG on TOP: 122.99,167.46 125.97,167.46 125.97,164.54 122.99,164.54
VCC3V3_PREREG on BOTTOM: 113.98,166.88 115.57,166.88 115.57,166.39 116.97,166.39 116.97,171.13 115.06,171.13 113.28,172.91 109.33,172.91 108.18,171.75 108.18,169.29 112.66,169.29 113.98,167.97
VCC3V3_PREREG on BOTTOM: 70.23,153.92 85.98,153.92 85.98,159.89 70.23,159.89
VCC3V3_PREREG on BOTTOM: 28,69.02 28,64.9 32.07,64.9 32.07,67.18 31.18,67.18 31.18,69.02
VCC3V3_PREREG on BOTTOM: 182.52,173.1 185.8,173.1 185.8,176.73 182.52,176.73
VCC3V3_PREREG on BOTTOM: 165.93,167.18 165.93,168.91 166.05,169.04 166.05,171.2 161.61,171.2 161.61,167.18
VCC3V3_PREREG on BOTTOM: 157.2,176.23 157.2,173.25 157.28,173.18 158.29,173.18 158.6,173.48 158.6,175.03 159.18,175.62 159.18,176.33 157.3,176.33
VCC3V3_PREREG on BOTTOM: 136.78,170.88 136.78,171.86 127.71,171.86 127.71,177.22 136.75,177.22 138.52,175.45 145.35,175.45 145.35,170.88 143,170.88 143,172.4 139.26,172.4 139.26,170.88
VCC3V3_PREREG on L06_PWR1: 8.13,64.77 8.13,156.55 9.57,157.39 8.13,158.23 8.13,176.78 209.17,176.78 209.17,148.18 194.09,148.18 184.28,157.99 154.43,157.99 154.43,162.94 145.92,162.94 145.92,158.5 104.65,158.5 104.65,140.65 90.42,140.65 90.42,151.13 89.79,151.76 20.47,151.76 17.91,149.2 17.91,99.19 34.54,82.55 34.54,76.58 32.64,74.68 32.64,66.67 30.73,64.77 ; 7 cut-outs
VCC3V3_TA on BOTTOM: 137.36,6.53 139,6.53 139,8.83 138.94,8.89 138.94,11.02 137.36,11.02
VCC3V3_TA on L10_SIG3: 110.01,53.11 110.01,9.86 139.19,9.86 139.19,14.66 137.11,16.74 137.11,20.68 145.97,20.68 148.79,23.5 148.79,53.11 141.35,53.11 141.38,53.14 141.38,58.85 142.54,60.02 142.54,60.63 142.32,60.86 139.45,60.86 138.18,59.59 138.18,56.64 134.65,53.11 ; 3 cut-outs
VCC3V3_TA on L12_SIG4: 144.02,36.32 144.02,22.86 146.84,22.86 146.84,36.32
VCC3V3_TA_OPT on TOP: 14.5,26.95 14.5,20.42 19.99,20.42 19.99,26.95
VCC3V3_TA_OPT on BOTTOM: 41.66,149.71 41.66,143.61 42.39,142.88 49.56,142.88 50.27,143.59 50.27,147.88 49.63,148.51 43.59,148.51 42.98,149.12 42.98,149.5 42.77,149.71
VCC3V3_TA_OPT on L10_SIG3: 17.25,26.24 17.25,23.29 20.42,23.29 20.42,26.24
VCC3V3_TA_OPT on L10_SIG3: 39.57,151.56 39.57,141.63 44.22,141.63 44.22,151.56
VCC3V3_XDS on TOP: 108.65,6.92 108.65,5.27 111.51,5.27 111.51,6.92
VCC3V3_XDS on L07_PWR2: 42.48,59.44 54.61,59.44 56.13,57.91 56.13,51.94 52.64,48.45 52.64,36.89 53.66,35.88 62.42,35.88 66.29,32 66.29,16.26 71.68,10.87 84.91,10.87 86.94,12.9 107.59,12.9 109.63,10.87 111.84,10.87 112.79,9.92 112.79,5.48 111.11,3.8 99.31,3.8 98.57,3.05 97.56,3.05 96.47,1.96 91.41,1.96 90.58,2.79 90.58,4.86 89.15,6.29 48.26,6.29 35.75,18.8 35.75,62.36 36.45,63.06 41.97,63.06 42.48,62.55
VCC_2V5 on TOP: 198.11,158.44 198.11,156.68 202.63,156.68 202.63,158.44
VCC_2V5 on L05_SIG2: 198.76,158.37 198.76,157.48 200.41,157.48 200.41,158.37
VCC_2V5 on L08_PWR3: 198.32,158.62 198.32,156.21 194.46,152.35 194.46,146.94 196.49,146.94 196.49,147.57 195.66,148.41 195.66,151.59 200.46,156.39 202.82,156.39 202.82,158.62
VCC_3V3_FT4232 on L08_PWR3: 8.19,124.33 8.19,135.19 9.31,135.19 11.3,137.19 11.3,139.04 11.73,139.47 11.73,143.36 15.43,147.07 31.75,147.07 34.49,144.33 34.49,128.64 30.18,124.33 23.19,124.33 22.89,124.64 22.89,128.27 22.2,128.96 16.76,128.96 16.1,128.3 16.1,125.12 15.32,124.33
VCC_5V0 on BOTTOM (solid shape): 174.35,48.62 172.65,48.62 172.65,48.46 172.39,48.46 172.39,48 172.08,47.68 171.99,47.23 172.39,46.99 172.39,46.96 173.76,46.96 173.76,45.36 170.59,45.36 170.59,47.51 170.96,47.51 170.96,48.72 171.25,48.72 171.25,49.66 170.59,49.66 170.59,50.93 174.35,50.93
VCC_5V0 on TOP: 15.18,143.89 15.18,142.43 18.54,142.43 18.54,143.89
VCC_5V0 on TOP: 57.4,65.66 58.93,65.66 58.93,60.9 57.4,60.9
VCC_5V0 on BOTTOM: 168.28,48.64 168.28,41.68 166.88,41.68 166.88,44.01 166.76,44.13 166.76,45.28 164.34,45.28 164.34,48.64
VCC_5V0 on BOTTOM: 70.87,122.17 85.98,122.17 85.98,117.35 84.96,117.35 84.96,115.32 70.87,115.32
VCC_5V0 on BOTTOM: 119.95,146.65 122.36,146.65 122.43,146.58 122.43,139.6 119.06,139.6 119.06,145.25 119.95,145.25
VCC_5V0 on L08_PWR3: 57.47,62.74 57.47,60.52 58.55,60.52 58.55,62.74
VCC_5V0 on L08_PWR3: 15.05,143.51 15.05,142.37 17.02,142.37 17.02,143.51
VCC_5V0 on L08_PWR3: 70.87,113.22 84.55,113.22 94.04,103.73 94.04,39.35 173.76,39.35 173.76,50.96 153.54,50.96 153.54,48.96 114.87,48.96 107.31,56.52 107.31,118.11 123.38,134.18 123.38,146.43 105.79,146.43 105.79,140.21 102.36,136.78 99.06,136.78 89.15,126.87 70.87,126.87
VCC_12V0 on TOP: 78.99,163.77 78.99,153.16 84.07,153.16 84.07,154.05 94.61,154.05 94.61,163.77
VCC_12V0 on BOTTOM: 121.92,151.66 121.92,148.74 122.62,148.04 122.62,147.03 122.36,146.77 120.02,146.77 118.3,148.49 118.3,151.66
VCC_12V0 on L08_PWR3: 90.18,145.29 90.18,163.3 123.83,163.3 123.83,145.29
VCC_OLDI_5V0 on BOTTOM (solid shape): 180.85,45.42 175.84,45.42 175.84,46.51 178.56,46.51 178.57,46.45 178.58,46.4 178.6,46.35 178.62,46.3 178.66,46.25 178.7,46.21 178.74,46.18 178.79,46.16 178.85,46.14 178.9,46.13 178.96,46.13 179.01,46.13 179.07,46.15 179.12,46.17 179.16,46.2 179.21,46.23 179.24,46.27 179.28,46.32 179.3,46.37 179.32,46.42 179.32,46.48 179.32,46.54 179.32,46.59 179.3,46.64 179.28,46.69 179.24,46.74 179.21,46.78 179.16,46.82 179.12,46.85 179.07,46.87 179.01,46.88 178.96,46.89 178.9,46.89 178.85,46.88 178.79,46.86 178.74,46.83 178.7,46.8 178.66,46.76 178.62,46.72 178.6,46.67 178.58,46.62 178.57,46.56 178.56,46.51 175.84,46.51 175.84,46.99 178.05,46.99 178.16,47.09 178.16,50.88 180.85,50.88
VCC_OLDI_5V0 on L06_PWR1 (solid shape): 179.53,44.73 179.27,44.73 179.24,44.74 179.19,44.76 179.13,44.77 179.08,44.77 179.03,44.76 178.98,44.74 178.94,44.73 175.54,44.73 175.54,46.34 175.55,46.37 175.57,46.42 175.59,46.48 175.59,46.51 178.56,46.51 178.57,46.45 178.58,46.4 178.6,46.35 178.62,46.3 178.66,46.25 178.7,46.21 178.74,46.18 178.79,46.16 178.85,46.14 178.9,46.13 178.96,46.13 179.01,46.13 179.07,46.15 179.12,46.17 179.16,46.2 179.21,46.23 179.24,46.27 179.28,46.32 179.3,46.37 179.32,46.42 179.32,46.48 179.32,46.54 179.32,46.59 179.3,46.64 179.28,46.69 179.24,46.74 179.21,46.78 179.16,46.82 179.12,46.85 179.07,46.87 179.01,46.88 178.96,46.89 178.9,46.89 178.85,46.88 178.79,46.86 178.74,46.83 178.7,46.8 178.66,46.76 178.62,46.72 178.6,46.67 178.58,46.62 178.57,46.56 178.56,46.51 175.59,46.51 175.59,46.53 175.59,46.59 175.57,46.64 175.55,46.7 175.54,46.72 175.54,47.04 179.53,47.04
VCC_OLDI_5V0 on BOTTOM: 198.12,31.11 200.22,31.11 200.91,30.42 201.8,30.42 201.99,30.23 201.99,29.08 200.79,29.08 200.03,29.84 198.12,29.84
VCC_OLDI_5V0 on L06_PWR1: 201.32,29.62 201.32,34.26 197.87,34.26 197.87,29.62
VDD3V3_CLKBUF on TOP: 75.18,97.79 75.69,97.79 75.69,96.77 76.96,96.77 76.96,95.5 75.18,95.5
VDD_1V0 on TOP: 45.09,65.28 45.09,63.25 42.42,63.25 42.42,65.28
VDD_1V0 on TOP: 125.17,146.74 125.17,142.24 127.2,142.24 127.2,146.74
VDD_1V0 on BOTTOM: 43.05,65.41 43.05,63.25 43.81,63.25 43.81,65.41
VDD_1V0 on BOTTOM: 116.78,165.61 122.87,165.61 122.87,159 116.78,159
VDD_1V0 on BOTTOM: 125.16,146.65 125.16,145.22 125.09,145.16 125.09,143.28 127.38,143.28 127.38,146.33 127.06,146.65
VDD_1V0 on L07_PWR2: 56.9,64.39 56.9,80.96 62.87,86.93 62.87,101.98 36.77,128.08 36.77,136.63 127.32,136.63 127.32,147.7 123.57,151.45 123.57,164.64 74.54,164.64 68.9,159 28.68,159 25.72,156.04 25.72,115.19 42.29,98.62 42.29,63.25 55.75,63.25
VDD_2V5 on TOP: 34.42,75.69 39.94,75.69 39.94,71.27 34.16,71.27 34.16,74.8 34.42,74.8
VDD_2V5 on TOP: 45.34,65.66 46.1,65.66 46.1,59.82 44.2,59.82 44.2,61.09 45.34,62.23
VDD_2V5 on L08_PWR3: 28.32,119.32 47.34,119.32 60.25,106.4 60.25,59.56 33.02,59.56 33.02,85.34 36.07,88.39 36.07,94.74 33.02,97.79 33.02,107.31 27.88,107.31 27.88,118.87
VDD_CORE on TOP: 128.98,141.71 128.98,139.5 131.47,139.5 131.47,141.71
VDD_CORE on BOTTOM: 131.98,158.37 123.95,158.37 123.95,165.63 131.98,165.63
VDD_CORE on BOTTOM: 131.32,120.52 131.32,114.36 135,114.36 135,120.52
VDD_CORE on L07_PWR2: 124.08,165.68 124.08,151.45 127.64,147.89 127.64,103.12 137.41,93.34 152.78,93.34 153.07,93.63 153.07,105.06 142.11,116.01 142.11,157.25 138.43,160.93 138.43,165.68
VDD_DDR4 on BOTTOM: 175.77,159.32 175.77,153.61 179.9,153.61 179.9,159.32
VDD_DDR4 on L07_PWR2: 176.31,76.83 203.48,76.83 203.48,153.52 182.63,153.52 182.63,159.28 175.69,159.28 175.69,151.94 176.31,151.31 176.31,115.35 179.96,111.7 179.96,105.38 176.31,101.73
VDD_DLL_CORE on TOP: 124.1,141.73 124.1,139.5 128.47,139.5 128.47,141.73
VDD_DLL_CORE on L07_PWR2: 136.45,88.7 155.35,88.7 155.35,92.35 138.3,92.35 127.1,103.56 127.1,141.12 123.9,141.12 123.9,101.24 134.25,90.89 134.24,90.88 134.24,89.76 135.26,88.75 136.4,88.75
VDD_MCU on BOTTOM: 157.86,118.62 157.86,115.32 160.4,115.32 160.4,118.62
VDD_MCU on BOTTOM: 150.24,162.81 150.24,158.62 153.99,158.62 153.99,162.81
VDD_MCU on L06_PWR1: 151.26,99.57 151.64,99.95 151.64,106.55 160.02,114.94 160.02,118.75 159.77,119 156.85,119 146.18,108.33 146.18,102.23 143.74,102.23 143.61,102.11 143.61,100 143.79,99.82 144.91,99.82 145.16,99.57
VDD_MCU on L08_PWR3: 149.99,162.81 152.65,162.81 154.47,160.99 154.47,154.22 150.75,150.5 150.75,129.41 160.27,119.89 160.27,116.33 158.37,114.43 156.75,114.43 156.35,114.84 156.35,117.21 146.69,126.87 146.69,158.51 149.99,161.81
VDD_MMC1 on TOP: 177.08,48.99 177.08,47.33 178.1,47.33 178.18,47.24 178.18,46.48 177.93,46.23 176.4,46.23 175.9,46.74 175.9,49.89 176.94,50.93 176.94,51.82 178.69,51.82 178.69,49.28 177.36,49.28
VDD_MMC1 on BOTTOM: 182.27,58.64 182.27,52.48 177.83,52.48 177.83,49.96 177.77,49.91 176.63,49.91 175.97,50.57 175.97,52.76 176.78,53.57 178.97,53.57 179.96,54.56 179.96,55.24 179.2,56.01 179.2,58.01 180.04,58.85 182.06,58.85
VDD_MMC1_SD on TOP: 181.86,49 181.86,47.9 178.33,47.9 178.33,47.71 177.38,47.71 177.38,49
VDD_MPU on BOTTOM: 164.53,100.97 164.53,98.74 169.74,98.74 169.74,97.85 172.21,97.85 172.21,101.6 169.93,101.6 169.93,100.97
VDD_MPU on BOTTOM: 185.61,167.2 185.61,159.92 190.94,159.92 190.94,167.2
VDD_MPU on L08_PWR3: 151.32,104.52 150.62,103.82 150.62,101.79 149.29,100.46 149.29,94.74 149.67,94.36 176.41,94.36 181.7,99.65 181.7,149.89 192.98,161.16 192.98,166.94 186.23,166.94 185.29,166.01 185.29,165.16 185.36,165.1 185.36,163.26 172.21,150.11 172.21,102.87 161.86,102.87 160.21,104.52
VDDA1V8 on BOTTOM: 157.1,171.81 157.1,170.69 157.05,170.64 157.05,169.01 157.1,168.96 157.63,168.96 157.99,168.61 157.99,168.08 156.02,168.08 155.96,168.02 155.96,165.48 161.21,165.48 161.21,169.67 160.99,169.9 159.31,169.9 159.11,169.7 158.37,169.7 158.17,169.9 158.17,171.81
VDDA_1P8_OLDI on L06_PWR1: 151.14,91.33 151.14,90.99 150.64,90.5 150.64,85.14 153.19,82.59 153.19,81.26 154.09,81.26 154.11,81.27 154.11,83.07 151.75,85.43 151.75,91.15 151.57,91.33
VDDA_1V8 on BOTTOM: 151.57,80.26 151.57,77.41 155.83,77.41 155.83,80.26
VDDA_1V8 on BOTTOM: 129.79,95.63 129.79,92.56 130.1,92.56 130.1,91.34 127.79,91.34 127.79,92.91 125.61,92.91 125.61,96.02 125.77,96.02 125.78,96.01 126.77,96.01 126.77,97.36 127.03,97.61 127.75,97.61 127.75,96.67 128.8,96.67 128.8,95.63
VDDA_1V8 on BOTTOM: 150.5,116.01 150.5,117.22 152.91,117.22 152.91,118.68 156.08,118.68 156.08,116.01
VDDA_1V8 on BOTTOM: 126.95,111.86 129.92,111.86 129.92,112.89 128.93,112.89 128.93,113.08 127.48,114.53 127.48,115.6 129.39,115.6 129.39,117.24 127.46,119.17 123.04,119.17 123.04,114.54 125.44,114.54 126.95,113.03
VDDA_1V8 on BOTTOM: 156.08,164.66 156.08,160.97 160.53,160.97 160.53,164.66
VDDA_1V8 on L08_PWR3: 160.34,164.72 160.34,160.4 159.23,159.29 157.07,159.29 153.29,163.07 148.08,163.07 145.54,160.53 145.54,126.49 151.83,120.21 154.11,120.21 155.96,118.36 155.96,112.9 155.45,112.39 145.03,112.39 145.03,108.1 141.61,104.67 135.03,104.67 132.51,107.19 115.95,107.19 115.95,97.92 129.67,97.92 129.67,91.57 115.95,91.57 115.95,81.41 116.2,81.15 156.21,81.15 156.21,73.47 113.47,73.47 108.08,78.87 108.08,116.59 137.28,145.79 137.28,158.22 147.36,168.3 152.5,168.3 156.08,164.72 ; 2 cut-outs
VDDA_3P3_IOLDO_WKUP on BOTTOM: 137.19,101.93 137.19,101.22 140.79,101.22 140.79,101.7 140.97,101.7 141.76,102.49 141.76,102.79 141.43,103.12 138.21,103.12 137.86,102.78 136.74,102.78 136.47,102.51 136.47,102.08 136.63,101.93
VDDA_3P3_USB on BOTTOM: 135.28,98.31 135.28,97.76 140.51,97.76 140.51,99.06 141.07,99.62 141.07,100.28 140.64,100.71 140.03,100.71 139.31,99.99 134.84,99.99 131.89,102.95 130.63,102.95 130.56,102.87 130.56,100.91 130.78,100.69 132.9,100.69
VDDA_3V3_SDIO on BOTTOM: 164.6,94.55 164.6,95.76 164.77,95.93 164.77,96.57 162.38,96.57 162.37,96.57 162.1,96.57 160.67,95.14 160.67,94.53 161.11,94.09 163.75,94.09 164.22,94.55
VDDA_3V3_SDIO on L05_SIG2: 153.21,95.61 153.21,94.39 162,94.39 162,95.61
VDDA_GP3 on L08_PWR3: 133.65,98.42 142.88,98.42 142.88,100.73 145.92,100.73 145.92,99.14 144.68,99.14 144.68,97.27 132.8,97.27 132.61,97.46 132.61,98.58 132.77,98.73 133.35,98.73
VDDA_GP4 on L06_PWR1: 151.87,91.26 151.87,87.01 152.06,87.01 152.1,86.97 152.1,85.69 154.78,83.01 154.78,81.76 155.34,81.19 156.77,81.19 156.88,81.31 156.88,83.17 156.86,83.19 156.86,85.11 153.31,88.66 153.31,92.3 153.01,92.3 152.65,92.66 151.82,92.66 151.64,92.84 151.64,93.17 151.43,93.37 150.44,93.37 150.16,93.09 150.16,92.08 150.19,92.05 150.67,92.05 151.16,92.53 151.25,92.53 151.46,92.33 151.46,91.68
VDDA_GP9 on BOTTOM: 130.86,111.83 130.86,110.59 130.87,110.58 130.87,110.51 134.55,106.83 140.78,106.83 140.78,104.51 142.83,104.51 142.92,104.6 142.92,107.27 142.23,107.96 136.63,107.96 131.77,112.82 131.75,112.82 131.75,112.93 130.47,112.93 130.47,111.83
VDDA_PLL_MAIN on L06_PWR1: 134.12,91.96 134.12,93.07 134.85,93.8 136.6,93.8 136.83,93.57 142.67,93.57 142.86,93.76 142.86,95.64 142.98,95.76 144.07,95.76 144.07,95.74 144.49,95.74 144.49,92.86 135.03,92.86 135.03,91.96
VDDA_PLL_PER0 on BOTTOM: 124.78,114.25 124.78,111.87 126.4,111.87 126.4,113.36 126.39,113.36 125.5,114.25
VDDA_PLL_PER0 on L08_PWR3: 142.09,110.95 142.09,105.69 142.11,105.67 142.11,104.69 141.91,104.49 141.46,104.49 141.06,104.09 141.06,103.79 143.16,103.79 143.59,104.22 143.59,112.36 141.8,114.15 124.05,114.15 124.05,111.75 134.44,111.75 134.87,112.18 140.87,112.18
VDDA_SRAM_CORE on L12_SIG4: 144.35,94.67 145.29,93.73 147.9,93.73 148.41,93.22 148.41,92.71 148.74,92.38 150.34,92.38 150.65,92.68 150.65,93.85 150.42,94.08 150.16,94.08 149.38,94.87 146.38,94.87 145.44,95.81 145.44,96.75 144.63,96.75 144.35,96.47
VDDA_SYS_MON on L08_PWR3: 132.31,98.93 141.16,98.93 141.25,99.03 141.25,100.5 140.96,100.79 140.96,101.22 139.47,101.22 139.47,100.03 132.36,100.03 130.56,100.03 129.03,98.5 129.03,97.66 129.31,97.38 130.76,97.38
VDDR_VTT on TOP: 195.26,135.19 195.26,143.45 197.1,145.29 197.1,148.27 185.55,148.27 185.55,149.85 195.58,149.85 195.58,150.43 200.66,150.43 200.66,149.1 198.5,149.1 198.5,144.78 196.98,143.26 196.98,135.19
VDDR_VTT on BOTTOM: 195.26,143.45 195.26,134.36 196.98,134.36 196.98,143.45
VDDR_VTT on BOTTOM: 185.55,149.87 185.55,148.34 197.23,148.34 197.23,149.87
VDDS_OSC1 on L08_PWR3: 152.57,96.76 152.57,95.76 165.38,95.76 165.84,95.3 170.84,95.3 171.02,95.48 171.02,96.7 170.23,97.49 169.14,97.49 168.94,97.28 168.94,96.76
VDDSHV_SD_IO on L06_PWR1: 153.06,93.46 154.53,92.39 154.53,91.9 155.07,91.36 162.15,91.36 162.15,91.36 169.18,91.36 169.18,93.16 162.83,93.16 162.26,92.59 162.26,92.58 162.05,92.38 157.35,92.38 155.89,93.84 154.25,93.84 153.91,94.19 153.91,94.92 153.06,94.92
VIN on TOP: 43.05,155.57 43.05,143.08 58.99,143.08 58.99,155.57
VINPUT on TOP: 30.23,129.72 30.23,151.66 36.37,151.66 37.32,150.71 42.67,150.71 42.67,143.13 46.49,143.13 46.49,129.72
VINPUT on BOTTOM: 37.8,150.62 38.76,150.62 38.96,150.42 40.18,150.42 40.31,150.29 40.31,149.86 40.28,149.83 39.12,149.83 39.12,149.07 36.27,149.07 36.27,147.42 30.23,147.42 30.23,151.74 37.8,151.74
(no net) on TOP: outline of 83 points within 7.51,0.52 209.66,177.28 ; 117 cut-outs
(no net) on BOTTOM: 7.51,0.52 7.51,135.08 7.81,135.38 11.84,135.38 12.09,135.64 12.09,136.3 12.32,136.53 14.22,136.53 14.48,136.78 14.48,138.15 14.1,138.53 12.19,138.53 12.09,138.43 12.09,138.3 11.86,138.07 11.38,138.07 11.28,138.18 11.28,139.01 11.73,139.47 11.73,142.14 12.09,142.49 12.83,142.49 12.93,142.6 12.93,144.27 12.67,144.53 12.04,144.53 11.79,144.78 11.79,146.76 11.56,146.99 7.86,146.99 7.51,147.35 7.51,151.78 7.65,151.92 9.12,151.92 9.96,151.08 17.5,151.08 17.78,151.36 17.78,155.78 17.42,156.13 12.85,156.13 12.47,156.51 12.47,157.94 11.23,159.18 11.23,160.45 12.5,161.72 13.13,161.72 13.54,162.13 13.54,165.2 13.08,165.66 13.08,166.73 12.57,167.23 7.66,167.23 7.51,167.39 7.51,177.28 209.66,177.28 209.66,0.52 109,0.52 108.81,0.71 108.81,2.54 107.24,4.11 107.24,5 107.04,5.21 105.13,5.21 104.98,5.05 104.98,3.56 104.85,3.43 102.01,3.43 101.9,3.53 101.9,5.11 101.8,5.21 99.82,5.21 99.69,5.08 99.69,3.86 98.88,3.05 97.79,3.05 97.21,2.46 97.21,0.85 96.88,0.52 ; 129 cut-outs
(no net) on BOTTOM: 170.59,50.93 174.35,50.93 174.35,48.46 172.39,48.46 172.39,46.96 173.76,46.96 173.76,45.36 170.59,45.36
(no net) on BOTTOM: 132.4,171.37 132.4,169.42 136.35,169.42 136.35,171.37
(no net) on BOTTOM: 180.85,50.88 178.16,50.88 178.16,47.09 178.05,46.99 175.84,46.99 175.84,45.29 180.85,45.29
(no net) on BOTTOM: 145.8,171.26 145.8,169.54 149.67,169.54 149.67,171.26
(no net) on BOTTOM: 179.73,9.12 182.42,9.12 182.42,12.9 182.52,13 184.73,13 184.73,14.71 179.73,14.71
(no net) on BOTTOM: 48.39,125.98 48.39,121.28 57.02,121.28 57.02,125.98
(no net) on BOTTOM: 49.15,131.52 58.55,131.52 58.55,128.52 49.15,128.52
(no net) on BOTTOM: 189.99,9.35 186.46,9.35 186.46,11.53 188.19,11.53 188.19,13.03 186.82,13.03 186.82,14.63 189.99,14.63
(no net) on L03_SIG1: 7.49,0.51 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,156.46 8.6,156.46 9.54,157.39 8.6,158.32 7.49,158.32 7.49,161.21 8.6,161.21 9.54,162.14 8.6,163.07 7.49,163.07 7.49,177.29 209.68,177.29 209.68,0.51 106.98,0.51 106.77,0.71 106.77,1.6 105.82,2.56 104.86,1.6 104.86,0.71 104.65,0.51 102.23,0.51 102.02,0.71 102.02,1.6 101.07,2.56 100.11,1.6 100.11,0.71 99.9,0.51 ; 160 cut-outs
(no net) on L05_SIG2: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,153.77 7.76,154.03 9.09,154.03 10.95,155.88 11.96,155.88 12.24,156.16 12.24,157.96 12.01,158.19 10.54,158.19 10.39,158.34 10.39,161.06 10.57,161.24 12.24,161.24 12.67,161.67 12.67,165.2 12.22,165.66 7.77,165.66 7.51,165.93 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.72 104.65,0.52 102.23,0.52 102.04,0.72 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 188 cut-outs
(no net) on L06_PWR1: 175.54,44.73 175.54,47.04 179.53,47.04 179.53,44.73
(no net) on L10_SIG3: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,156.45 8.6,156.45 9.55,157.39 8.6,158.34 7.51,158.34 7.51,161.2 8.6,161.2 9.55,162.14 8.6,163.09 7.51,163.09 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.72 104.65,0.52 102.22,0.52 102.04,0.71 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 183 cut-outs
(no net) on L12_SIG4: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,156.45 8.6,156.45 9.55,157.39 8.6,158.34 7.51,158.34 7.51,161.2 8.6,161.2 9.55,162.14 8.6,163.09 7.51,163.09 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.72 104.65,0.52 102.23,0.52 102.04,0.72 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 178 cut-outs
CS on TOP: 85.85,139.95 95,139.95 95,135.25 85.85,135.25
DDR_VPP on TOP: 193.1,147.83 193.1,145.73 194.75,145.73 194.75,147.83
DDR_VPP on L08_PWR3: 197.31,147.07 197.31,78.42 181.55,78.42 181.55,81.2 185.42,81.2 185.42,91.5 182.5,91.5 182.5,94.7 185.42,94.7 185.42,106.17 182.05,106.17 182.05,108.5 185.42,108.5 185.42,119.89 182.05,119.89 182.05,122.36 185.42,122.36 185.42,133.22 182.36,133.22 182.36,136.18 185.42,136.18 185.42,147.07
FT4232_USB_VBUS on BOTTOM: 11.18,137.59 11.18,136.97 13.91,136.97 14.1,137.16 14.1,137.92 13.92,138.1 13.49,138.1 13.26,137.87 12.27,137.87 12.01,137.62 11.2,137.62
HS on TOP: 84.65,135 95.5,135 95.5,140.34 92.84,140.34 92.84,144.85 101.73,144.85 101.73,129.03 84.65,129.03
HS_L on TOP: 101.47,146.05 94.36,146.05 94.36,146.94 86.36,146.94 86.36,154.05 86.61,154.31 101.47,154.31
MAIN on TOP: 29.59,173.48 29.59,156.08 59.08,156.08 59.08,173.48
MCU_EARTH on TOP, L02_GND1, L04_GND2, L05_SIG2, L08_PWR3, L09_GND3, L10_SIG3, L11_GND4, L12_SIG4: 16.94,128.57 22.02,128.57 22.48,128.12 22.48,119.81 21.59,118.92 21.59,113.56 22.48,112.67 22.48,108.94 22.23,108.69 20.65,108.69 20.27,109.07 17.48,109.07 17.12,109.42 17.12,110.26 16.64,110.74 16.64,113.23 16.48,113.39 16.48,128.12
MCU_EARTH on BOTTOM, L13_GND5: 16.94,128.57 22.02,128.57 22.48,128.12 22.48,119.81 21.59,118.92 21.59,113.56 22.48,112.67 22.48,108.94 22.22,108.68 20.65,108.68 20.27,109.06 17.49,109.06 17.12,109.42 17.12,110.26 16.64,110.74 16.64,113.23 16.48,113.39 16.48,128.12
PRG_EARTH on L04_GND2: 8,78.61 8,104.78 34.93,104.78 34.93,78.61 ; 4 cut-outs
SHIELD on BOTTOM: 24.64,174.62 24.64,168.28 45.09,168.28 45.09,174.62
SOC_DVDD1V8 on TOP: 184.66,74.93 184.66,70.74 189.48,70.74 189.48,74.93
SOC_DVDD1V8 on BOTTOM: 169.16,91.58 169.16,89.92 170.31,89.92 170.56,89.66 172.1,89.66 172.45,90.02 172.45,95.63 172.33,95.76 171.28,95.76 171.16,95.63 171.16,94.44 171.02,94.3 169.39,94.3 169.23,94.13 169.23,91.64
SOC_DVDD1V8 on L08_PWR3: 140.34,99.57 146.06,99.57 146.06,106.28 146.83,107.06 150.11,107.06 150.11,101.47 149.1,100.46 149.1,94.49 149.48,94.11 179.2,94.11 179.2,77.22 179.71,76.71 187.71,76.71 189.61,74.8 189.61,70.87 188.72,69.98 175.64,69.98 175.64,69.09 175.01,68.45 172.21,68.45 171.7,68.96 171.7,71.75 169.93,73.53 169.93,86.74 144.4,86.74 140.34,90.81
SOC_DVDD3V3 on BOTTOM: 118.83,109.4 111.84,109.4 111.84,105.46 118.83,105.46
SOC_DVDD3V3 on BOTTOM: 125.88,105.66 125.88,99.8 127.38,98.3 128.91,98.3 128.85,98.35 128.85,99.64 128.65,99.85 128.65,100.36 128.55,100.46 128.34,100.46 128.34,101.92 129.73,101.92 129.73,101.93 129.73,104.47 128.96,104.47 128.91,104.52 128.91,105.61 129.41,106.12 129.9,106.12 130.13,106.36 130.13,107.06 127.99,107.06 127.99,105.89 127.76,105.66
SOC_DVDD3V3 on L06_PWR1: 147.83,99.42 147.83,98.93 148.08,98.68 152.78,98.68 154.89,96.57 154.89,94.31 154.31,93.73 150.37,93.73 150.24,93.6 150.24,88.14 145.92,88.14 141.35,92.71 139.95,92.71 139.95,101.73 145.21,106.99 145.9,106.99 145.95,107.04 146.08,106.91 146.08,99.87 146.53,99.42
SOC_DVDD3V3 on L08_PWR3: 141.07,103.43 142.2,103.43 142.2,105.28 145.64,105.28 145.9,105.02 145.9,100.88 145.06,100.04 142.12,100.04 141.37,100.78 140.23,100.78 140.23,98.86 139.8,98.42 136.65,98.42 135.41,99.67 133.5,99.67 131.94,98.11 118.02,98.11 114.98,101.14 114.98,112.86 119.94,112.86 126.02,106.77 132.17,106.77 134.59,104.34 140.16,104.34
SOC_MPU on BOTTOM: 176.91,171.7 182.18,171.7 182.18,170.31 182.5,169.99 182.5,167 184.96,167 184.96,159.87 182.4,159.87 182.4,161.48 176.91,161.48
SOC_VDDS_DDR on BOTTOM: 164.53,107.44 164.53,103.82 171.45,103.82 171.45,109.63 168.96,109.63 168.96,107.44
SOC_VDDS_DDR on BOTTOM: 164.6,158.05 164.6,153.48 160.4,153.48 160.4,158.05
SOC_VDDS_DDR on L06_PWR1: 160.15,157.73 160.15,152.53 172.97,152.53 172.97,129.92 166.5,123.44 157.23,123.44 155.32,121.54 155.32,112.38 157.22,110.48 168.92,110.48 169.74,109.66 169.74,107.51 170.05,107.19 173.61,107.19 174.62,108.2 179.71,108.2 180.98,109.47 180.98,143 185.04,147.07 193.29,147.07 194.31,148.08 184.66,157.73
SOC_VDDS_DDR on L07_PWR2: 153.29,105.41 160.4,105.41 164.72,109.73 171.2,109.73 171.58,109.35 171.58,106.3 171.2,105.92 168.66,105.92 167.64,104.9 167.64,100.84 163.7,96.9 154.31,96.9 153.29,97.92
USB1_SHIELD on TOP: 7.67,154.41 7.52,154.56 7.52,156.46 8.6,156.46 9.54,157.39 8.6,158.32 7.52,158.32 7.52,161.21 8.6,161.21 9.54,162.14 8.6,163.07 7.52,163.07 7.52,165 7.85,165.33 11.91,165.33 12.37,164.87 12.37,161.85 12.01,161.49 10.39,161.49 10.11,161.21 10.11,158.32 10.46,157.96 11.89,157.96 12.01,157.84 12.01,156.26 11.81,156.06 10.82,156.06 9.17,154.41
USB1_SHIELD on BOTTOM: 7.65,155.09 7.52,155.22 7.52,156.46 8.6,156.46 9.54,157.39 8.6,158.32 7.52,158.32 7.52,161.21 8.6,161.21 9.54,162.14 8.6,163.07 7.52,163.07 7.52,166.47 7.85,166.8 12.27,166.8 12.45,166.62 12.45,165.38 12.17,165.1 12.17,161.95 11.71,161.49 10.39,161.49 10.11,161.21 10.11,158.32 10.34,158.09 11.79,158.09 12.01,157.86 12.01,156.46 11.66,156.11 9.73,156.11 9.63,156.01 9.63,155.5 9.22,155.09
USB1_SHIELD on L02_GND1, L04_GND2, L05_SIG2, L06_PWR1, L07_PWR2, L08_PWR3, L09_GND3, L10_SIG3, L11_GND4, L12_SIG4, L13_GND5: 7.67,154.41 7.52,154.56 7.52,156.46 8.6,156.46 9.54,157.39 8.6,158.32 7.52,158.32 7.52,161.21 8.6,161.21 9.54,162.14 8.6,163.07 7.52,163.07 7.52,165 7.85,165.33 11.91,165.33 12.37,164.87 12.37,161.75 12.12,161.49 10.39,161.49 10.11,161.21 10.11,158.32 10.46,157.96 11.89,157.96 12.07,157.78 12.07,156.31 11.81,156.06 10.82,156.06 9.17,154.41
USB1_VBUS on TOP: 14.61,151.96 14.61,156.36 14.3,156.67 13.08,156.67 12.88,156.46 12.47,156.46 12.4,156.54 12.4,158.01 12.12,158.29 12.12,158.69 12.18,158.75 13.72,158.75 14.54,157.92 15.23,157.92 15.39,157.76 16,157.76 16.26,157.51 16.26,156.24 15.95,155.93 15.95,155.24 16,155.19 16,153.67 17.72,153.67 17.72,151.96
VMAIN on TOP: 75.56,137.67 75.56,129.86 80.9,129.86 80.9,137.67
VMAIN on TOP: 53.78,134.17 53.78,137.99 47.08,137.99 47.08,142.56 66.29,142.56 66.29,134.17
VMAIN on BOTTOM: 47.75,129.67 47.75,141.86 66.29,141.86 66.29,134.24 53.78,134.24 53.78,131.06 48.64,131.06 48.64,129.67
VMAIN on BOTTOM: 75.06,129.79 79.25,129.79 79.25,135 84.58,135 84.58,131.44 89.56,131.44 89.56,142.49 85.09,142.49 85.09,138.7 75.06,138.7
VMAIN on L07_PWR2: 61.48,141.93 79.79,141.93 79.79,129.65 74.3,129.65 74.3,134.28 61.48,134.28
VMAIN on L08_PWR3: 61.48,142.29 79.79,142.29 79.79,129.65 74.3,129.65 74.3,134.28 61.48,134.28
VPP_1V8 on TOP: 123.37,169.98 125.78,169.98 125.78,174.96 121.56,174.96 121.03,174.42 121.03,171.91 123.37,171.91
VPP_1V8 on BOTTOM: 146.24,116.01 146.24,117.6 147.57,117.6 147.57,116.01
VPP_1V8 on L08_PWR3: 120.78,175.21 120.78,170.35 128.1,170.35 128.1,175.21
VPP_CORE_MCU on BOTTOM: 146.43,115.26 146.43,111.89 147.22,111.1 147.22,107.04 145.36,107.04 145.36,104.57 146.84,104.57 146.84,105.18 146.9,105.25 147.61,105.25 147.68,105.18 147.68,104.67 148.49,104.67 148.49,112.12 147.55,113.06 147.55,115.26
VPP_CORE_MCU on L10_SIG3: 145.06,105.11 145.06,102.21 145.75,101.52 147.12,101.52 147.22,101.42 147.22,96.29 148.26,95.25 150.57,95.25 151.05,94.77 151.05,92.41 151.82,91.64 155.58,91.64 155.7,91.77 155.7,92.56 155.3,92.96 152.7,92.96 152.02,93.65 152.02,95.66 151.03,96.65 148.87,96.65 148.08,97.43 148.08,102.21 147.57,102.72 146.66,102.72 146.52,102.85 146.52,105.11 146.25,105.11 145.92,105.44 145.39,105.44
XDS_SHIELD on TOP: 97.6,0.81 97.6,2.31 97.96,2.67 99.06,2.67 100.08,3.68 100.08,4.65 100.23,4.8 101.73,4.8 101.73,3.05 105.16,3.05 105.16,4.8 106.68,4.8 106.81,4.67 106.81,3.94 108.43,2.31 108.43,0.89 108.18,0.64 106.93,0.64 106.81,0.76 106.81,2.29 106.43,2.67 105.41,2.67 104.78,2.03 104.78,0.64 102.11,0.64 102.11,2.16 101.6,2.67 100.58,2.67 100.08,2.16 100.08,0.68 99.93,0.53 97.88,0.53
XDS_SHIELD on BOTTOM, L02_GND1, L04_GND2, L05_SIG2, L06_PWR1, L07_PWR2, L08_PWR3, L09_GND3, L10_SIG3, L11_GND4, L12_SIG4, L13_GND5: 97.84,0.51 97.66,0.69 97.66,2.31 98.02,2.67 99.06,2.67 100.08,3.68 100.08,4.65 100.23,4.8 101.35,4.8 101.52,4.62 101.52,3.35 101.83,3.05 105.03,3.05 105.36,3.38 105.36,4.65 105.51,4.8 106.68,4.8 106.81,4.67 106.81,3.94 108.43,2.31 108.43,0.64 108.31,0.51 106.98,0.51 106.77,0.71 106.77,1.6 105.82,2.56 104.86,1.6 104.86,0.71 104.65,0.51 102.23,0.51 102.02,0.71 102.02,1.6 101.07,2.56 100.11,1.6 100.11,0.71 99.9,0.51
XDS_USB_VBUS on TOP: 104.35,7.11 104.35,6.6 104.78,6.6 104.78,5.46 108.33,5.46 108.33,7.11
N17781485 on BOTTOM: 31.94,64.14 31.94,60.01 33.72,60.01 33.72,64.14
N17781689 on BOTTOM: 162.56,159.23 166.5,159.23 166.5,163.8 165.02,165.28 165.02,166.56 162.56,166.56
N17781734 on BOTTOM: 177.23,174.94 177.23,172.47 182.05,172.47 182.05,174.94
N17785477 on BOTTOM (solid shape): 58.55,128.52 56.64,128.52 56.64,128.55 49.78,128.55 49.78,128.52 49.15,128.52 49.15,130.68 54.17,130.68 54.17,131.52 58.55,131.52
N17785477 on L03_SIG1: 41.5,133.4 41.5,128.3 58.06,128.3 58.06,133.4
N17785477 on L10_SIG3: 41.94,131.75 41.94,127.71 58.01,127.71 58.01,131.75
N17785579 on BOTTOM: 114.49,164.66 114.49,163.26 114.24,163 114.24,159 115.95,159 115.95,162.94 115.7,163.19 115.7,164.66
N17786037 on TOP: 33.65,78 39.75,78 39.75,80.1 34.16,80.1 33.65,79.59
N17839730 on BOTTOM: 9.91,151.57 9.91,154.81 10.67,155.57 17.08,155.57 17.08,151.57
N18546005 on TOP: 59.56,164.47 59.56,146.43 68.12,146.43 68.12,164.47
N18968753 on TOP: 15.75,148.34 17.78,148.34 17.78,146.56 18.73,146.56 18.73,145.1 15.75,145.1
N19753729 on BOTTOM: 81.28,130.18 81.28,127.25 99.06,127.25 99.06,131.19 84.71,131.19 84.71,130.18
N19753760 on BOTTOM: 86.61,123.95 86.61,117.6 87.38,117.6 87.38,116.4 99.38,116.4 99.38,123.95
N19754201 on BOTTOM: 81.15,147.45 81.15,143 99.25,143 99.25,147.45
N19754522 on BOTTOM: 86.74,158.62 86.74,150.56 99.5,150.56 99.5,158.62
N23093100 on BOTTOM: 127.08,171.91 127.08,170.08 127.53,169.62 131.72,169.62 131.72,171.91
N23093100 on L08_PWR3: 127.05,174.8 127.05,171.48 128.37,171.48 128.37,174.8
N23093100 on L12_SIG4: 127.43,174.22 127.43,173.38 127.58,173.23 127.58,171.22 128.22,171.22 128.22,174.22
N23728299 on BOTTOM: 41.86,150.22 41.86,149.78 43.18,149.78 43.18,149.35 43.81,148.72 49.83,148.72 50.06,148.95 50.06,152.04 49.81,152.3 43.97,152.3 43.89,152.22 43.89,150.32 43.79,150.22
N23956742 on BOTTOM (solid shape): 136.35,169.42 132.4,169.42 132.4,171.37 136.35,171.37
N23956744 on BOTTOM (solid shape): 149.67,169.54 145.8,169.54 145.8,171.26 149.67,171.26

Small or netless copper shapes (teardrops, artwork): 2466 on TOP, 1542 on BOTTOM, 1 on L02_GND1, 501 on L03_SIG1, 619 on L05_SIG2, 4 on L06_PWR1, 9 on L07_PWR2, 5 on L08_PWR3, 442 on L10_SIG3, 515 on L12_SIG4

## Text on the board
Ref Des/Assembly Bottom: D | C | B | A | ASSEMBLY BOTTOM CP CARD REV A
Ref Des/Silkscreen Bottom: DGND | VDD_2V5 | VPP_1V8 | R | EXT | INT | VCC1V0 | SoC_AVDD1V8 | VDDA1V8 | VCC1V2_DDR | SOC_MPU | VDD_MPU | VCC1V8 | SoC_DVDD3V3 | VDD_1V0 | VDD_CORE | PORz | VDD_MCU | SoC_VDDS_DDR | SOC_SAFETY_ERRORZ | VDD_DDR | MIPI | DISPLAY | NOT FCC APPROVED FOR RESALE | FOR EVALUATION ONLY;
User.Comments: BOARD NAME: | AM654x EVM PROCESSOR BOARD | REV: B | DATE: 09/04/2021 | DESCRIPTION: | SHEET | OF | 21 | PROC062 | SCALE: 1 | CR_ETHERNET_1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: ASSEMBLY TOP CP CARD REV B
Ref Des/Silkscreen Top: VINPUT | B | VCC_12V0 | VCC_5V0 | VCC3V3_PREREG | VCC3V3_IO | A | DGND | TA_POWER SEL | I2C1_SCL | I2C1_SDA | SoC_DVDD1V8 | VCC_2V5 | USB2 Port 1 | VMAIN | MIPI | cTI | 1V8 | 3V3 | MCU_SDA | MCU_SCL | VDDR_VTT | ETHERNET | MCU | 12V-24V 10A MAX | XDS110_USB | PORz | JTAG_MUX_SEL | MCU_BOOTMODE | MCU_BOOT MODE | BOOTMODE SW | CSI LVL | WARM_RST | MCU_PUSH BUTTON | ADC | Expansion Card | 1.8V max | Serdes | TIMER | SPI1 | UART | PRU2 | ETH0/ETH1 | 12V-24V 5A MAX | JTAG | WKUP UART0 | SD CARD | OFF | CSI2 CAMERA | ON | APPLICATION CARD | MCU UART1 | PCB #:3P0014 | ASSM #:4P0081 | ASSM REV ___ | AM654x EVM PROCESSOR BOARD | PROC062B
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | VU/UD | AMB | ZA | DATE | 280421 | SIZE | SCALE: | D | NONE | SHEET 1 OF 21 | PROC062 | Rev | B | TEXAS INSTRUMENTS | AM654x EVM PROCESSOR BOARD
DISPLAY_BOTTOM: 1 | 2 | S/N
DISPLAY_TOP: 2 | 12 | 30 | 48 | 29 | A5 | A9 | B5 | B9 | 37 | 36 | 25 | A6 | B1 | B6 | 4 | 5 | 9 | 8 | 6 | 3 | 13 | 24 | 14 | 7 | B11 | B14 | A14 | A11 | A10 | B10 | 16
User.6: 14 | 7 | 8 | 3 | 9 | 10 | 2 | 60 | 30 | 31 | 19 | 24 | 18 | 13 | 6 | 12 | 5 | 4 | B18 | B17 | A17 | A18 | B2 | B1 | A2
User.7: 18. | 17. | 15. | 16. | ENSURE THAT UL REGISTERED E-FILE NUMBER SHALL BE PRINTED ON PCB SILKSCREEN | FOR STACKUP DETAILS PROC062_STACKUP.pdf SHALL BE REFERRED. | REMOVE ALL NON FUNCTIONAL VIA PAD ONLY ON ALL INTERNAL LAYERS. | ALL THE IMPEDANCE SHALL BE MATCHED AS PER IMPEDANCE TABLE WITH +/-10% TOLERANCE. | DIA WITH 40MIL DRILL HAS A DUPLICATE HOLE AT ONE OF THE LOCATION, THIS SHALL BE IGNORED DURING FABRICATION. | AND QUANTITY CAN BE CONSIDERED AS 11 HOLES. | VIA HOLES THAT HAVE MASK OPEN SHALL BE FILLED WITH NON CONDUCTIVE EPOXY MATERIAL AND CAP PLATED, | PER SIDE SHALL BE REDUCED IF REQUIRED. | DETAIL-A
User.11: 10 | 9 | 2 | 60 | 30 | 3 | 4 | 5 | 31 | 6 | J5 | C49 | J4 | U5 | R53 | R52 | C39 | C40 | C42 | R58 | R51 | C48 | R56 | C43 | R57 | C47 | U9 | NOT FCC APPROVED | FOR RESALE | FOR EVALUATION ONLY; | C44 | R55 | R54 | C41 | R60 | R50 | R49 | R59 | C36 | C38 | C37
User.12: 2 | 3 | 16 | 8 | 9 | 5 | 4 | 17 | 64 | 59 | 60 | 32 | 49 | 48 | 33 | 14 | 15 | 6 | 28 | 120 | 62 | 61 | 119 | Q20 | Q8 | R247 | R227 | Q11 | R226 | R246 | R237 | Q17 | Q7 | R224 | Q22 | R245 | R248 | R219 | R241 | Q5 | Q16 | Q21 | Q12 | R240 | U51 | R236 | R239 | Q6 | R235 | Q15 | C124 | C112 | C120 | C160 | C154 | C156 | C109 | C148 | R215 | C106 | R209 | U46 | R344 | R343 | C163 | C157 | R432 | C118 | C117 | R210 | R216 | R330 | R331 | R435 | R427 | R430 | R107 | R66 | C35 | C31 | C43 | C26 | C42 | C46 | R12 | C147 | R398 | C134 | R428 | R404 | U7 | U9 | R400 | C116 | R405 | C105 | C115 | U14 | R443 | R130 | J16 | C65 | R136 | R412 | R314 | R414 | C145 | R392 | U15 | C37 | C36 | R396 | C137 | R310 | R311 | R129 | C111 | C104 | R222 | R221 | C49 | C50 | C62 | Q4 | R131 | R238 | R258 | R260 | R223 | R244 | R242 | Q19 | Q18 | FL6 | C108 | Q14 | U6 | U45 | R231 | R229 | U47 | R316 | R323 | R318 | Q10 | R322 | Q9 | Q13 | R225 | C30 | R438 | R437 | R436 | R234 | C172 | R211 | U50 | R243 | R442 | C169 | R214 | R228 | R232 | R254 | R212 | R217 | R253 | R233 | R213 | R218 | R262 | R257 | R261 | R256 | C162 | C110 | C125 | C158 | C114 | C149 | C44 | C41 | R431 | C171 | R342 | C170 | R341 | R338 | R335 | R336 | R452 | R446 | R327 | R457 | R326 | R453 | R456 | R15 | R399 | R406 | R347 | R397 | R348 | R429 | R345 | R346 | R403 | R447 | R401 | R402 | R451 | C45 | C27 | C33 | C34 | R67 | R113 | R68 | R112 | R423 | C32 | C40 | R424 | R394 | R420 | R395 | C59 | C128 | C132 | R393 | R56 | R450 | R58 | R409 | R60 | R408 | R87 | R62 | R90 | R92 | R95 | C107 | R317 | R324 | R315 | R230 | R320 | R319 | R321 | R259 | R220 | R440 | R439 | C168 | J17 | C167 | R441 | A | B | Not FCC approved for resale | For Evaluation only;
User.13: 7 | 8 | 4 | 5 | A31 | B31 | B32 | A32 | B12 | A12 | A10 | 3 | B2 | A2 | 2 | 24 | 19 | 6 | B10 | B1 | 18 | 13 | 12 | USB 2.0 | PCIe x2 | EXT | RESET | INT | HOST_SEL | ASSM REV : 1.0 | ASSM P/N : 4P0088 | PCB Number:3P0021 | PCB REV:E3 | PROC067 | OP#
User.25: GROUND-PLANE-05 | 16
User.28: INNER-SIGNAL-04 | 15
User.41: 02 | 03 | 04 | 05 | 06 | 07 | 08 | 10 | 11 | 12 | STRIPLINE | EDGE COUPLED STRIPLINE | MICROSTRIP | EDGE COUPLED MICROSTRIP | L5 | L3 | L3,L5 | L10,L12 | L1 | L1,L14 | 3.0 | 4.3 | 3.3 | 4.2 | 4.1 | 6.2 | 10.5 | 5.2 | 8.2 | 3.5 | 7.9 | 4.4 | NA | 7.4 | 5.3 | 5.0 | 100 | 80 | 50 | 90 | 85 | 40 | L2/L4,L4/L6 | L9/L11,L11/L13 | L11/L13 | L4/L6 | L2/L4 | L2,L13 | L4
User.42: 0.5oz+PLATING
User.45: PROC062 | 21 | OF | SECONDARY-SILKSCREEN | SHEET | DESCRIPTION: | DATE: 28/08/2019 | REV: E4 | AM654x EVM PROCESSOR BOARD | BOARD NAME: | 19 | SCALE: 1 | FIGURE | SIZE | 8.0 | 24.0 | 32.0 | 36.0 | 40.0 | 44.0 | 46.0 | 66.0 | 86.0 | 34.0 | 42.0 | 56.0 | 68.0 | 88.0 | 108.0 | 126.0 | 52.0x24.0 | 64.0x32.0 | 86.0x24.0 | 98.0x24.0 | 120.0x30.0 | 140.0x40.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-4.0 | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 4804 | 10 | 2 | 5 | 38 | 36 | 63 | 6 | 8 | 12 | 3 | 4 | 14 | 1 | TEXAS INSTRUMENTS | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC062A ASSEMBLY TOP | PROC062A ASSEMBLY BOTTOM | PROC062A  ASSEMBLY BOTTOM
