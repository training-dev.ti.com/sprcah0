# Allegro board PROC062B_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_SPI0_CS1: length 113.8
  TOP w0.132: U34.AF13 v1(138.36,99.39) ; J16.24 v1(52.93,62.87)
  L10_SIG3 w0.084: v1(52.93,62.87) 53.34,62.46 56.62,62.46 57.61,63.45 69.1,63.45 85.39,79.73 104.5,79.73 111.38,86.61 111.38,99.59 v1(113.26,101.47)
  L12_SIG4 w0.084: v1(113.26,101.47) 114.04,100.69 125.35,100.69 126.67,102.01 135.04,102.01 136.46,100.58 137.73,100.58 137.96,100.35 137.96,99.78 v1(138.36,99.39)
SOC_SPI0_D0: length 144.7
  TOP w0.132: J16.26 52.43,62.45 v1(51.93,61.95) ; R123.1 v1(104.3,115.57) 101.3,115.57 U24.D3 ; U34.AE13 v1(139.16,99.39)
  L05_SIG2 w0.084: v1(139.16,99.39) 138.91,99.39 138.52,99.78 130.53,99.78 130.3,100.01 123.89,100.01 123.25,100.65 122.36,100.65 118.11,104.9 112.52,104.9 105.85,111.57 105.85,114.02 v1(104.3,115.57)
  L10_SIG3 w0.084: v1(51.93,61.95) 52.39,62.41 52.39,63.31 54.64,65.56 54.64,79.6 52.33,81.91 52.33,88.15 53.44,89.25 53.44,90.71 54.9,92.18 79.11,92.18 98.62,111.68 101.7,111.68 104.11,114.1 104.49,114.1 104.76,114.36 104.76,115.11 v1(104.3,115.57)
SOC_SPI0_D1: length 143.6
  TOP w0.132: U24.D2 102.27,114.55 v1(104.29,114.55) R126.1 ; J16.28 v1(51.93,62.87) ; U34.AD13 v1(139.96,99.39)
  L05_SIG2 w0.084: v1(104.29,114.55) 104.03,114.82 104.03,114.83 103.85,115.01 103.85,115.76 104.11,116.03 104.49,116.03 107.15,113.37 107.15,111.04 112.78,105.41 118.03,105.41 121.72,101.73 126.05,101.73 126.78,100.99 135.86,100.99 136.27,100.58 139.33,100.58 139.56,100.35 139.56,100.03 139.57,100.03 139.57,99.96 139.96,99.57 v1(139.96,99.39)
  L10_SIG3 w0.084: v1(104.29,114.55) 103.82,114.55 101.26,111.99 98.49,111.99 81.37,94.87 69.72,94.87 69.52,95.07 57.33,95.07 53.22,90.97 52.6,90.97 51.36,89.73 51.36,78.76 52.65,77.47 52.65,75.2 53.39,74.46 53.39,65.07 51.93,63.61 v1(51.93,62.87)
SOC_SPI1_CLK: length 192.6
  L03_SIG1 w0.084: v1(112.51,34.73) 112.51,36.71 112.39,36.82 112.39,47.02 110.72,48.69 110.72,56.75 113.64,59.67 113.64,92.26 117.29,95.91 122.47,95.91 123.06,95.32 123.06,94.5 v1(122.54,93.98)
  L05_SIG2 w0.084: v1(164.54,34.52) 167.19,31.86 182.69,31.86 183.84,33.02 190.97,33.02 J20.4
  L10_SIG3 w0.084: v1(164.54,34.52) 163.36,33.34 152.22,33.34 151.07,32.18 115.06,32.18 v1(112.51,34.73)
  L12_SIG4 w0.084: J20.4 196.43,34.42 201.04,34.42 203.2,32.26 203.2,17.39 v1(200.51,14.7)
  BOTTOM w0.132: v1(164.54,34.52) 165.04,35.02 J35.48 ; J38.32 v1(200.51,14.7) ; R489.1 v1(122.54,93.98)
SOC_SPI1_CLK_R: length 16.7
  TOP w0.132: U34.AH12 v1(136.76,100.19)
  L10_SIG3 w0.084: v1(136.76,100.19) 136.14,100.19 136.08,100.13 132.46,100.13 130.25,97.92 127.12,97.92 125.35,96.15 125.35,95.89 124.73,95.26 v1(124.73,93.98)
  BOTTOM w0.132: R489.2 v1(124.73,93.98)
SOC_SPI1_CS: length 3.4
  TOP w0.132: J20.3 R316.1 R317.1
SOC_SPI1_CS0: length 145.8
  TOP w0.132: v1(197.17,14.2) 197.17,33.6 196.62,34.14 R317.2 v1(191.54,34.82) ; U34.AD12 v1(139.96,100.19)
  L05_SIG2 w0.084: v1(145.47,81.28) 145.15,81.6 145.15,85.97 145.15,85.98 145.15,97.22 144.44,97.93 140.83,97.93 140.35,98.41 140.35,99.8 v1(139.96,100.19)
  L10_SIG3 w0.084: v1(191.54,34.82) 178.66,34.82 176.97,36.51 176.97,39 180.11,42.13 180.11,72.37 176.91,75.56 176.01,75.56 174.88,76.69 174.88,77.98 173.1,79.76 163.2,79.76 158.62,75.18 153.67,75.18 148.21,80.65 146.1,80.65 v1(145.47,81.28)
  BOTTOM w0.132: R675.1 v1(197.17,14.2)
SOC_SPI1_CS1: length 121.4
  TOP w0.132: v1(163.54,38.58) R311.1 167.64,37.85 170.37,35.12 189.49,35.12 R316.2 ; U34.AG12 v1(137.56,99.39)
  L03_SIG1 w0.084: v1(142.11,55.75) 140.21,57.66 140.21,75.93 v1(139.57,76.57)
  L05_SIG2 w0.084: v1(142.11,55.75) 143.27,56.91 164.07,56.91 166.35,54.63 166.35,45.21 165.54,44.4 165.54,40.59 v1(163.54,38.58) ; v1(139.57,76.57) 138.81,77.33 138.81,83.82 139.55,84.55 139.55,86.43 139.55,86.43 139.55,88.37 139.78,88.6 140.12,88.6 140.12,88.6 140.17,88.6 140.35,88.77 140.35,89.16 140.57,89.38 140.94,89.38 141.16,89.6 141.16,96.45 141.02,96.6 140.59,96.6 140.36,96.83 140.36,97.13 140.12,97.38 139.73,97.38 138.75,98.36 138.75,98.75 138.52,98.98 137.96,98.98 v1(137.56,99.39)
SOC_SPI1_MISO: length 185.1
  TOP w0.132: U34.AF12 v1(138.36,100.19)
  L05_SIG2 w0.084: v1(164.54,35.43) 164.08,34.98 164.08,34.29 166.81,31.56 182.94,31.56 183.77,32.38 186.53,32.38 J20.2 ; v1(138.36,100.19) 138.54,100 138.79,100 138.99,99.8 139.3,99.8 139.32,99.78 139.32,99.78 139.55,99.55 139.55,98.34 140.37,97.51 144.13,97.51 144.36,97.28 144.36,81.19 v1(145.47,80.09)
  L10_SIG3 w0.084: v1(145.47,80.09) 145.8,79.76 148.67,79.76 153.54,74.88 158.83,74.88 163.4,79.45 172.97,79.45 174.57,77.85 174.57,76.57 175.88,75.26 176.78,75.26 179.8,72.24 179.8,42.26 173.48,35.94 165.05,35.94 v1(164.54,35.43)
  L12_SIG4 w0.084: J20.2 189.31,32.38 193.8,32.38 196.14,34.72 201.17,34.72 203.5,32.38 203.5,15.7 v1(200.51,12.7)
  BOTTOM w0.132: J38.36 v1(200.51,12.7) ; J35.46 v1(164.54,35.43)
SOC_SPI1_MOSI: length 230.1
  TOP w0.132: U34.AE12 v1(139.16,100.19)
  L03_SIG1 w0.084: v1(139.16,100.19) 139.16,100.36 139.55,100.75 139.55,101.24 139.7,101.4 140.1,101.4 140.36,101.13 140.36,98.33 140.53,98.17 144.91,98.17 145.15,97.93 145.15,95.23 144.92,95 141.41,95 141.16,94.75 141.16,92.84 140.92,92.6 140.61,92.6 140.36,92.35 140.36,85.63 137.24,82.5 126.1,82.5 114.33,70.73 114.33,65.08 115.1,64.31 115.1,59.51 v1(111.54,55.95)
  L05_SIG2 w0.084: J20.1 166.61,30.99 163.54,34.06 v1(163.54,34.52) 163,35.05 163,39.75 164.53,41.27 164.53,44.55 164.93,44.95 164.93,45.49 165.49,46.05 165.49,54.98 163.96,56.52 155.73,56.52 153.77,54.56 135.07,54.56 130.38,49.87 127.05,49.87 126.34,50.58 125.14,50.58 120.48,55.24 112.24,55.24 v1(111.54,55.95)
  L12_SIG4 w0.084: J20.1 187.16,32.77 193.75,32.77 196.01,35.03 201.29,35.03 203.81,32.51 203.81,14.71 201.36,12.26 200.02,12.26 v1(199.58,12.7)
  BOTTOM w0.132: v1(163.54,34.52) 164.04,35.02 J35.44 ; v1(199.58,12.7) 200.08,13.2 J38.35
SOC_TCK: length 134.9
  TOP w0.132: R241.2 v1(115.76,64.06) ; U34.AA4 v1(142.36,106.59)
  L03_SIG1 w0.084: v1(115.76,64.06) 116.08,64.38 116.08,71.62 126.35,81.89 139.04,81.89 141.96,84.81 141.96,92.35 142.21,92.6 142.52,92.6 142.75,92.83 142.75,93.13 143.01,93.4 146.52,93.4 146.75,93.63 146.75,99.55 146.5,99.8 142.19,99.8 141.96,100.03 141.96,105.95 142.36,106.34 v1(142.36,106.59)
  L05_SIG2 w0.084: v1(115.76,64.06) 115.3,63.6 114.14,63.6 113.21,64.53 113.21,66.08 112.63,66.65 81.63,66.65 79.56,64.59 73.44,64.59 v1(61.4,52.55)
  BOTTOM w0.132: R623.2 61.26,52.05 61.4,52.2 v1(61.4,52.55)
SOC_TDI: length 171.7
  TOP w0.132: v1(114.58,64.06) 114.08,64.56 U43.4 ; U34.C20 v1(157.56,92.99)
  L05_SIG2 w0.084: v1(59.1,52.55) 60.2,53.65 60.2,53.89 74.63,68.33 113.92,68.33 116.21,66.04 116.21,65.69 v1(114.58,64.06) 115.18,64.06 115.59,64.46 119.19,64.46 120.24,63.41 120.24,56.77 125.52,51.5 130.65,51.5 135.64,56.49 135.64,66.83 137.08,68.27 157.4,68.27 v1(157.73,67.94)
  L12_SIG4 w0.084: v1(157.56,92.99) 157.39,92.99 156.98,93.4 155.76,93.4 155.58,93.22 155.58,92.05 155.86,91.76 156.11,91.76 156.39,91.48 156.39,91.24 156.6,91.02 156.88,91.02 157.19,90.72 157.19,90.44 157.45,90.17 159.77,90.17 163.32,86.61 163.32,73.95 162.57,73.2 162.48,73.2 159.96,70.68 159.96,69.41 159.4,68.85 158.64,68.85 v1(157.73,67.94)
  BOTTOM w0.132: v1(59.1,52.55) U98.4
SOC_TDO: length 206.4
  TOP w0.132: v1(176.38,74.76) 174.29,74.76 167.87,81.18 167.87,92 166.47,93.4 164.99,93.4 R208.2
  L05_SIG2 w0.084: v1(135.23,57.53) 134.54,57.53 128.81,51.8 125.64,51.8 120.55,56.9 120.55,63.55 115.47,68.63 74.6,68.63 58.65,52.68 58.65,50.36 v1(56.99,48.7) 50.23,48.7 43.69,55.25 43.69,58.78 v1(44.32,59.42)
  L10_SIG3 w0.084: v1(176.38,74.76) 177.58,73.56 177.58,70.57 174.14,67.12 173.59,67.12 168.3,67.12 163.17,61.99 162.35,61.18 152.97,61.18 149.12,65.02 142.83,65.02 135.66,57.85 135.55,57.85 v1(135.23,57.53)
  BOTTOM w0.132: U101.2 56.59,47.48 56.54,47.53 56.54,47.87 56.54,48.26 v1(56.99,48.7) ; U97.2 44.15,59.6 v1(44.32,59.42)
SOC_TMS: length 180.3
  TOP w0.132: v1(176.47,73.85) 174.56,73.85 167.6,80.81 167.6,91.75 166.96,92.4 163.49,92.4 163.27,92.18 160.03,92.18 159.62,92.59 U34.A21 ; U43.6 115.24,65.56 v1(115.68,65.99) 115.99,66.31 132.95,66.31 134.05,65.21 134.05,60.24 v1(133.29,59.47)
  L05_SIG2 w0.084: v1(115.68,65.99) 114.41,67.26 81.38,67.26 79.32,65.21 72.07,65.21 60.59,53.73 60.59,53.04 v1(59.1,51.55)
  L10_SIG3 w0.084: v1(133.29,59.47) 136.85,59.47 142.08,64.7 142.71,65.33 149.25,65.33 153.1,61.48 162.23,61.48 168.17,67.42 173.71,67.42 174.01,67.42 177.28,70.69 177.28,73.04 v1(176.47,73.85)
  BOTTOM w0.132: U98.6 v1(59.1,51.55)
SOC_TRST#: length 144.2
  TOP w0.132: v1(114.77,66.09) 114.32,66.09 114.29,66.06 U43.7 ; R130.1 v1(141.48,113.33) ; U34.AA3 v1(142.36,107.39)
  L03_SIG1 w0.084: v1(141.48,113.33) 141.8,113.01 141.8,112.71 142.76,111.74 142.76,107.87 142.36,107.46 v1(142.36,107.39) 141.96,107 141.96,106.45 141.72,106.2 141.41,106.2 141.16,105.95 141.16,99.23 141.39,99 145.7,99 145.95,98.75 145.95,94.43 145.7,94.18 142.19,94.18 141.96,93.95 141.96,92.84 141.96,92.84 141.7,92.58 141.39,92.58 141.16,92.35 141.16,84.44 138.91,82.2 126.23,82.2 114.77,70.74 v1(114.77,66.09)
  L05_SIG2 w0.084: v1(114.77,66.09) 113.89,66.96 81.5,66.96 79.47,64.93 72.22,64.93 60.9,53.61 60.9,52 v1(61.34,51.55)
  BOTTOM w0.132: v1(61.34,51.55) 60.84,51.05 U98.7
SOC_UART1_CTS_1V8: length 76.5
  TOP w0.132: U34.AD22 v1(139.96,91.39) ; v1(88.63,107.43) 89.28,106.78 U26.12
  L05_SIG2 w0.084: v1(139.96,91.39) 139.56,91 139.01,91 138.76,90.75 138.76,90.45 138.75,90.43 138.75,90.43 138.52,90.2 138.08,90.2 137.96,90.08 137.96,89.58 137.77,89.38 136.3,89.38 135.59,88.67 135.38,88.67 134.24,87.53 133.93,87.53 133.1,86.69 130.96,86.69 127,82.73 119.79,82.73 111.96,90.56 111.96,101.81 104.96,108.81 90.01,108.81 v1(88.63,107.43)
SOC_UART1_RTS_1V8: length 78.4
  TOP w0.132: U26.9 v1(87.33,106.39) ; U34.AC21 v1(140.76,92.19)
  L05_SIG2 w0.084: v1(87.33,106.39) 87.65,106.71 87.65,107.1 89.67,109.12 105.09,109.12 112.27,101.94 112.27,90.68 119.92,83.03 126.87,83.03 130.84,86.99 132.97,86.99 133.81,87.83 134.11,87.83 136,89.73 136,90.54 136.46,91 138.52,91 138.75,91.23 138.75,91.53 138.99,91.78 140.35,91.78 v1(140.76,92.19)
SOC_USB1_VBUS: length 184.1
  TOP w0.132: U34.AF6 v1(138.36,104.99) ; v1(16.25,155.53) R28.2 16.93,155.52 R34.1
  L05_SIG2 w0.084: v1(140.59,155.13) 137.78,157.94 120.19,157.94 116.16,153.9 106.65,153.9 105.73,152.97 18.81,152.97 v1(16.25,155.53)
  L12_SIG4 w0.084: v1(140.59,155.13) 141.03,154.69 141.03,149.62 141.96,148.69 141.96,145.79 141,144.83 141,133.12 140.46,132.59 140.46,132.21 137.33,129.07 137.33,117.58 137.15,117.4 137.15,109.6 137.15,109.6 137.15,107.58 137.95,106.78 137.95,105.4 v1(138.36,104.99)
SOC_VDDS_DDR: length 3.4
  TOP w0.203: U34.G14 v1(154.36,98.59) ; U34.H13 v1(153.56,99.39) ; U34.H9 v1(153.56,102.59) ; U34.G10 v1(154.36,101.79) ; U34.G8 v1(154.36,103.39) ; U34.H7 v1(153.56,104.19)
  vias: v1(160.77,155.83) v1(160.77,154.81) v1(160.77,153.8) v1(161.79,155.83) v1(161.79,154.81) v1(161.79,153.8) v1(170.05,109.29) v1(170.18,108.4) v1(170.18,107.51) v1(170.94,109.35) v1(171.2,108.41) v1(171.2,107.52)
SOC_WARM_RESETZ: length 143.2
  TOP w0.132: R309.1 113.93,40.98 114.02,40.89 v1(114.03,40.89) 116.35,40.89 117.22,41.76 117.22,45.72 116.84,46.1 115.44,46.1 115.02,46.53 U52.2 ; U34.F17 v1(155.16,95.39)
  L03_SIG1 w0.084: v1(155.16,95.39) 155.55,95 159,95 159.39,94.61 159.39,92.49 167.79,84.09 167.79,69.7 173.3,64.19 173.3,61.62 172.19,60.5 172.19,53.24 172.54,52.88 172.54,48.29 171.58,47.33 171.58,45.4 v1(172.47,44.51)
  L10_SIG3 w0.084: v1(172.47,44.51) 170.5,42.55 168.66,42.55 163.13,37.02 163.13,34.35 162.42,33.64 152.1,33.64 150.94,32.49 121.64,32.49 114.03,40.1 v1(114.03,40.89)
SOC_WKUP_SCL: length 610.8
  TOP w0.132: v1(186.56,15.94) 185.87,16.63 U56.6 ; J5.33 v1(156.14,144.56) ; U34.AC7 v1(140.76,104.19) ; U7.14 145.06,156.74 145.44,157.13 153.75,157.13 153.98,157.35 154.29,157.35 v1(154.68,156.97) ; U46.14 v1(90.05,60.08) 89.6,60.53 89.6,61.15 89.98,61.53 90.74,61.53 92.9,63.7 92.9,66.55 91.19,68.26 81.98,68.26 75.39,74.85 56.06,74.85 54.93,73.73 J16.15
  L03_SIG1 w0.084: v1(129.46,172.09) 132.08,169.47 152.53,169.47 154.86,167.13 154.86,158.88 155.12,158.62 155.12,157.4 v1(154.68,156.97) 153.87,156.15 153.87,151.84 154.88,150.82 154.88,145.82 v1(156.14,144.56)
  L05_SIG2 w0.084: v1(186.31,169.67) 185.48,170.5 173.47,170.5 169.8,166.83 162.31,166.83 160.66,165.18 160.66,160.72 157.43,157.49 155.21,157.49 v1(154.68,156.97) ; v1(186.56,15.94) 195.58,15.94 196.72,17.08 196.72,38.5 192.83,42.39 171.17,42.39 170.17,43.4 170.17,43.59 170.17,46.01 168.48,47.7 168.48,55.88 165.48,58.88 165.48,62.61 161.14,66.95 v1(161.14,68.01) 159.8,66.67 156.46,66.67 155.47,67.67 137.36,67.67 136.25,66.55 136.25,56.17 130.26,50.18 127.18,50.18 126.47,50.89 125.26,50.89 117.41,58.74 91.39,58.74 v1(90.05,60.08)
  L12_SIG4 w0.084: v1(156.14,144.56) 156.83,143.87 156.83,142.4 148.67,134.24 148.21,134.24 146.91,132.94 146.91,128.91 146.79,128.79 146.79,128.43 143.26,124.89 143.26,123.1 141.84,121.69 141.84,120.37 143.38,118.83 143.38,111.13 141.97,109.71 141.97,104.88 141.71,104.62 141.19,104.62 v1(140.76,104.19) ; v1(186.56,15.94) 180.15,22.35 170.82,22.35 168.88,24.28 168.88,32.21 166.55,34.54 166.55,35.66 166.12,36.09 155.35,36.09 v1(154.43,35.18) ; v1(161.14,68.01) 162.15,69.02 164.96,69.02 167.94,66.04 168.78,66.04 169.03,66.29 169.04,67.05 169.8,67.82 172.97,67.82 173.74,68.58 173.74,75.56 175.39,77.22 198.23,77.22 201.03,80.01 201.03,140.86 193.36,148.53 193.36,164.09 187.78,169.67 v1(186.31,169.67)
  BOTTOM w0.132: v1(90.05,60.08) 90.89,59.25 TP71.1 ; U59.D3 185.83,170.15 v1(186.31,169.67) ; J35.6 154.54,35.28 v1(154.43,35.18) ; v1(186.56,15.94) 189.82,19.2 J38.23 ; v1(129.46,172.09) 128.98,172.57 U61.E3 ; v1(161.14,68.01) 160.85,67.72 R584.2
SOC_WKUP_SDA: length 615.1
  TOP w0.132: U7.15 153.64,157.39 v1(154.68,158.43) ; v1(183.47,15.98) U56.5 ; J5.34 155.34,144.27 v1(156.14,143.47) ; J16.17 54.43,73.68 55.87,75.12 75.5,75.12 82.09,68.53 91.3,68.53 93.16,66.66 93.16,63.59 90.57,60.99 v1(90.05,60.99) 90.7,60.34 U46.15 ; U34.AD6 v1(139.96,104.99)
  L03_SIG1 w0.084: v1(156.14,143.47) 156.14,143.98 154.57,145.55 154.57,150.64 153.56,151.66 153.56,157.31 v1(154.68,158.43) 154.61,158.5 154.61,167.03 152.43,169.21 131.22,169.21 129.01,171.42 129.01,172.39 v1(129.54,172.92)
  L05_SIG2 w0.084: v1(186.33,170.84) 173.38,170.84 169.67,167.13 162.18,167.13 160.35,165.3 160.35,160.85 157.3,157.8 155.31,157.8 v1(154.68,158.43) ; v1(90.05,60.99) 91.99,59.05 117.53,59.05 125.39,51.19 126.59,51.19 127.3,50.48 130.13,50.48 135.94,56.29 135.94,66.67 137.24,67.97 155.6,67.97 156.55,67.02 159.68,67.02 160.73,68.07 160.73,68.18 160.97,68.41 161.65,68.41 v1(162.05,68.01) 162.05,66.47 166.47,62.05 166.47,58.47 168.86,56.08 168.86,47.65 170.4,46.11 170.4,43.49 171.27,42.63 193.02,42.63 197.1,38.55 197.1,16.38 195.71,14.99 184.47,14.99 v1(183.47,15.98)
  L12_SIG4 w0.084: v1(155.58,34.42) 156.13,34.98 164.97,34.98 168.58,31.37 168.58,23.93 170.43,22.07 177.38,22.07 v1(183.47,15.98) ; v1(186.33,170.84) 187.03,170.14 187.74,170.14 193.67,164.22 193.67,148.74 201.33,141.07 201.33,79.76 198.41,76.83 175.51,76.83 174.12,75.44 174.12,68.45 173.23,67.56 169.93,67.56 169.29,66.93 169.29,66.17 168.91,65.79 167.51,65.79 164.58,68.72 162.3,68.72 162.05,68.47 v1(162.05,68.01) ; v1(139.96,104.99) 139.96,105.06 140.36,105.47 140.36,109.15 141.61,110.39 141.61,112.33 141.08,112.86 141.08,118.04 141.37,118.33 141.37,123.92 146.32,128.88 146.32,133.02 148.01,134.71 148.21,134.71 148.47,134.71 156.14,142.38 v1(156.14,143.47)
  BOTTOM w0.132: U61.E2 v1(129.54,172.92) ; TP72.1 90.59,61.53 v1(90.05,60.99) ; R583.2 161.86,67.82 v1(162.05,68.01) ; U59.D2 v1(186.33,170.84) ; v1(183.47,15.98) 184.02,15.43 186.75,15.43 190.02,18.7 J38.24 ; v1(155.58,34.42) 156.54,35.38 J35.14
SOC_WKUP_UART0_CTS_3V3: length 42.1
  TOP w0.132: U34.AC2 v1(140.76,108.19) ; U23.5 110.61,115.86 v1(110.75,116)
  L05_SIG2 w0.084: v1(110.75,116) 109.98,115.24 109.98,109.98 111.12,108.84 114.22,108.84 116.03,107.04 119.15,107.04 122.03,109.92 126.56,109.92 127.54,108.93 135.01,108.93 136.14,107.8 140.36,107.8 v1(140.76,108.19)
SOC_WKUP_UART0_RTS_3V3: length 41.5
  TOP w0.132: U21.7 v1(111.61,118.88) ; U34.AC1 v1(140.76,108.99)
  L05_SIG2 w0.084: v1(111.61,118.88) 112.83,117.66 112.83,115.78 114.82,113.79 119.13,113.79 120.07,112.85 120.07,111.33 120.87,110.53 130.47,110.53 131.45,109.54 140.2,109.54 v1(140.76,108.99)
  L12_SIG4 w0.084: v1(111.61,118.88) 113.72,118.88 114.05,118.55 J11.2
SOC_WKUP_UART0_RX_3V3: length 38.4
  TOP w0.132: U34.AB1 v1(141.56,108.99)
  L05_SIG2 w0.084: v1(141.56,108.99) 141.16,108.6 136.14,108.6 135.51,109.24 131.06,109.24 130.08,110.22 118.3,110.22 118.01,109.93 116.36,109.93 115.77,109.35 111.12,109.35 110.39,110.08 110.39,113.82 v1(110.74,114.18)
  BOTTOM w0.132: U83.5 110.56,114.36 v1(110.74,114.18)
SOC_WKUP_UART0_TX_3V3: length 57.6
  TOP w0.132: v1(111.61,117.96) 111.21,118.36 U21.6 ; U34.AB5 v1(141.56,105.79)
  L05_SIG2 w0.084: v1(141.56,105.79) 141.16,105.4 137.23,105.4 136.72,105.92 135.7,105.92 134.15,107.47 120.62,107.47 118.92,105.77 113.13,105.77 109.6,109.3 109.6,116.45 111.12,117.96 v1(111.61,117.96)
  BOTTOM w0.132: J11.5 113.78,123.62 113.78,120.14 v1(111.61,117.96)
SPI0_RSTN: length 5.8
  TOP w0.132: U24.A4 R153.1 U28.4
SPI0_WP: length 3.4
  TOP w0.132: R127.1 99.33,114.49 U24.C4
SS: length 5.9
  TOP w0.132: U14.7 77.32,142.71 78.55,141.48 80.94,141.48 81.53,140.89 C63.1
SUPERVISOR_DEBOUNCE_RSTN: length 26.9
  TOP w0.132: U54.1 103.39,37.58 107.33,33.64 C243.1 ; C243.1 107.33,31.37 107.49,31.21 Q7.2 ; C243.1 R319.1 D11.1 SW8.1 SW8.2
SUPERVISOR_MR_RSTN: length 14.7
  TOP w0.132: U49.1 113.31,49.3 111.82,47.82 104.2,47.82 103.89,47.5 103.89,46.25
SYS_BOOTMODE0: length 23.3
  L05_SIG2 w0.084: v1(126.53,41.02) 126.94,41.44 127.21,41.44 128.27,42.5 132.41,42.5 135.02,45.11 143.13,45.11 144.35,46.33 v1(144.35,46.79)
  BOTTOM w0.132: U99.1 144.85,47.28 144.35,46.79 v1(144.35,46.79) ; U102.3 v1(126.53,41.02)
SYS_BOOTMODE1: length 25.6
  L05_SIG2 w0.084: v1(144.35,47.7) 144.8,47.25 144.8,46.36 143.25,44.81 135.15,44.81 130.76,40.42 126.99,40.42 126.53,39.96 v1(126.53,39.88)
  BOTTOM w0.132: U102.4 126.03,40.38 v1(126.53,39.88) ; U99.2 v1(144.35,47.7)
SYS_BOOTMODE2: length 23.6
  L05_SIG2 w0.084: v1(143.35,46.79) 143.35,46.33 142.74,45.72 134.77,45.72 132.16,43.11 127.99,43.11 126.94,42.05 126.1,42.05 125.53,41.48 v1(125.53,41.02)
  BOTTOM w0.132: U99.3 143.85,47.28 143.35,46.79 v1(143.35,46.79) ; U102.5 v1(125.53,41.02)
SYS_BOOTMODE3: length 26.1
  L05_SIG2 w0.084: v1(125.53,39.88) 125.98,40.34 125.98,41.28 126.45,41.74 127.09,41.74 128.14,42.8 132.28,42.8 134.9,45.42 142.86,45.42 143.8,46.36 143.8,47.25 v1(143.35,47.7)
  BOTTOM w0.132: U102.6 125.03,40.38 v1(125.53,39.88) ; U99.4 v1(143.35,47.7)
SYS_BOOTMODE4: length 28.5
  L05_SIG2 w0.084: v1(142.35,46.79) 141.89,46.33 123.67,46.33 122.54,45.2 122.54,42.65 123.71,41.48 124.07,41.48 v1(124.53,41.02)
  BOTTOM w0.132: U99.5 142.85,47.28 142.35,46.79 v1(142.35,46.79) ; U102.7 v1(124.53,41.02)
SYS_BOOTMODE5: length 26.1
  L05_SIG2 w0.084: v1(124.53,39.88) 124.98,40.34 124.98,41.51 125.83,42.35 126.81,42.35 127.87,43.41 132.03,43.41 134.65,46.03 142.23,46.03 142.8,46.6 142.8,47.25 v1(142.35,47.7)
  BOTTOM w0.132: v1(124.53,39.88) 124.03,40.38 U102.8 ; U99.6 v1(142.35,47.7)
SYS_BOOTMODE6: length 27.4
  L05_SIG2 w0.084: v1(123.53,41.02) 122.24,42.31 122.24,45.35 123.67,46.79 v1(141.35,46.79)
  BOTTOM w0.132: U99.7 141.85,47.28 141.35,46.79 v1(141.35,46.79) ; U102.9 v1(123.53,41.02)
SYS_BOOTMODE7: length 29.6
  L05_SIG2 w0.084: v1(141.35,47.7) 140.74,47.09 123.55,47.09 121.98,45.52 121.93,45.44 121.93,41.47 v1(123.53,39.88)
  BOTTOM w0.132: U102.10 123.03,40.38 v1(123.53,39.88) ; U99.8 v1(141.35,47.7)
SYS_BOOTMODE8: length 29.7
  L12_SIG4 w0.084: v1(141.77,34.99) 143.07,36.29 143.07,38.57 142.3,39.33 141.95,39.69 135.38,39.69 134.42,40.65 134.42,49.33 134.89,49.8 v1(138.83,49.8)
  BOTTOM w0.132: U105.3 v1(141.77,34.99) ; v1(138.83,49.8) 138.83,49.8 139.33,49.3 U99.9
SYS_BOOTMODE9: length 33.1
  L12_SIG4 w0.084: v1(139.75,49.8) 139.29,50.26 134.81,50.26 134.11,49.57 134.11,40.52 135.25,39.38 141.82,39.38 142,39.2 142.76,38.44 142.76,36.65 141.31,35.2 141.31,34.3 v1(141.77,33.85)
  BOTTOM w0.132: U105.4 141.27,34.35 v1(141.77,33.85) ; U99.10 v1(139.75,49.8)
SYS_BOOTMODE10: length 31.3
  L12_SIG4 w0.084: v1(140.77,34.99) 141.06,35.28 141.06,35.39 142.25,36.59 142.25,38.52 141.69,39.08 135.13,39.08 133.81,40.4 133.81,49.69 135.32,51.21 137.9,51.21 138.3,50.8 v1(138.83,50.8)
  BOTTOM w0.132: U105.5 v1(140.77,34.99) ; U99.11 139.33,50.3 138.83,50.8 v1(138.83,50.8)
SYS_BOOTMODE11: length 30.4
  L12_SIG4 w0.084: v1(140.77,33.85) 140.31,34.3 140.31,35.34 139.54,36.11 137.67,36.11 133.5,40.27 133.5,49.82 135.19,51.51 138.23,51.51 138.48,51.26 139.29,51.26 v1(139.75,50.8)
  BOTTOM w0.132: v1(140.77,33.85) 140.27,34.35 U105.6 ; U99.12 v1(139.75,50.8)
SYS_BOOTMODE12: length 28
  L12_SIG4 w0.084: v1(138.83,51.8) 135.06,51.8 133.2,49.95 133.2,40.14 137.54,35.8 139.41,35.8 139.77,35.45 v1(139.77,34.99)
  BOTTOM w0.132: U99.13 139.33,51.3 138.83,51.8 v1(138.83,51.8) ; U105.7 v1(139.77,34.99)
SYS_BOOTMODE13: length 31
  L12_SIG4 w0.084: v1(139.75,51.8) 139.29,52.26 135.08,52.26 132.89,50.07 132.89,40.02 137.41,35.5 138.91,35.5 139.31,35.09 139.31,34.3 v1(139.77,33.85)
  BOTTOM w0.132: v1(139.77,33.85) 139.27,34.35 U105.8 ; U99.14 v1(139.75,51.8)
SYS_BOOTMODE14: length 28.7
  L12_SIG4 w0.084: v1(138.83,52.8) 135.19,52.8 132.59,50.2 132.59,39.89 137.49,34.99 v1(138.77,34.99)
  BOTTOM w0.132: U99.15 139.33,52.3 138.83,52.8 v1(138.83,52.8) ; U105.9 v1(138.77,34.99)
SYS_BOOTMODE15: length 31.4
  L12_SIG4 w0.084: v1(138.77,33.85) 138.16,33.85 132.28,39.73 132.28,50.32 135.22,53.26 139.29,53.26 v1(139.75,52.8)
  BOTTOM w0.132: U105.10 138.27,34.35 v1(138.77,33.85) ; U99.16 v1(139.75,52.8)
SYS_BOOTMODE16: length 11.2
  BOTTOM w0.132: U95.4 140.5,62.41 139.96,61.87 139.96,56.64 142.35,54.25 U99.19
SYS_BOOTMODE17: length 11.8
  BOTTOM w0.132: U95.5 140.57,62.91 139.57,61.91 139.57,56.65 141.85,54.37 U99.18
SYS_BOOTMODE18: length 12.4
  BOTTOM w0.132: U95.6 140.62,63.41 139.19,61.98 139.19,56.66 141.35,54.5 U99.17
TCA6424_EXP_INT: length 1.9
  BOTTOM w0.132: R630.1 146.72,48.41 145.83,49.3 U99.32
TCA9555_EXP_INT: length 1.8
  BOTTOM w0.132: R661.1 81.27,20.28 80.84,19.85 80.84,19.84 80.77,19.77 U110.22
TEMP_DIODE_P: length 22.3
  TOP w0.132: U34.W6 v1(143.96,104.99)
  L05_SIG2 w0.084: v1(125.41,104.71) 125.82,104.31 134.84,104.31 135.89,103.25 137.94,103.25 138.19,103 141.75,103 141.98,103.24 141.98,103.54 142.2,103.76 142.51,103.76 142.74,103.99 142.74,104.3 143.02,104.58 143.55,104.58 v1(143.96,104.99)
  BOTTOM w0.132: TP53.1 v1(125.41,104.71)
TEST_GPIO1: length 29.3
  BOTTOM w0.132: Q18.1 139.03,27.83 137.62,26.42 129.81,26.42 129.19,25.8 129.19,17.05 127.85,15.71 125.94,15.71 125.42,15.19 125.42,13.56 R683.1 R692.1
TEST_GPIO2: length 26.6
  BOTTOM w0.132: Q19.1 135.47,27.83 134.37,26.72 129.74,26.72 128.93,25.91 128.93,17.3 127.6,15.97 125.24,15.97 124.39,15.12 124.39,13.41 124.02,13.04 R684.1 R693.1
TEST_GPIO3: length 14.2
  TOP w0.132: v1(122.87,11.89) 122.24,12.52 113.97,12.52 TP90.1
  BOTTOM w0.132: R773.1 122.73,12.03 v1(122.87,11.89) R694.1
TEST_GPIO4: length 79.4
  L03_SIG1 w0.084: v1(147.36,51.8) 150.27,51.8 151.9,50.16 151.9,40.13 156.08,35.95 156.08,34.37 156.92,33.53 156.92,25.08 152.82,20.98 138.2,20.98 133.78,16.56 v1(126.87,16.56)
  BOTTOM w0.132: R695.1 121.86,12.08 121.63,12.31 121.63,13.02 R685.1 121.06,13.02 120.93,13.16 120.93,15.62 TP65.1 v1(126.87,16.56) ; U99.28 146.87,51.3 147.36,51.8 v1(147.36,51.8)
TEST_PORZN: length 33.4
  TOP w0.132: Q7.1 v1(107.33,29.31)
  L03_SIG1 w0.084: v1(126.94,11.89) 125.97,10.92 122.75,10.92 121.79,11.87 121.79,17.12 109.6,29.31 v1(107.33,29.31)
  BOTTOM w0.132: R690.1 v1(126.94,11.89) R681.1
TEST_POWERDOWN: length 254.6
  L12_SIG4 w0.084: v1(27.07,156.53) 27.07,153.84 32,148.91 32,129.79 31.63,129.42 31.63,120.65 32.13,120.14 32.13,109.6 36,105.73 36,86.93 26.29,77.22 26.29,16.57 31.64,11.23 127.29,11.23 v1(127.95,11.89)
  BOTTOM w0.132: R352.2 v1(27.07,156.53) U66.5 ; R689.1 v1(127.95,11.89)
TEST_WARMRESETN: length 33.3
  BOTTOM w0.132: R691.1 R682.1 126.42,13.54 126.42,15.04 126.82,15.44 128.12,15.44 129.46,16.78 129.46,25.69 129.92,26.15 143.04,26.15 144.69,27.8 Q20.1
TG: length 5.8
  TOP w0.132: TP3.1 141.73,170.45 142.01,170.73 v1(142.01,172.4) 142.46,172.85 R4.1
  BOTTOM w0.132: U130.7 141.6,172.18 141.82,172.4 142.01,172.4 v1(142.01,172.4)
TIMER_IO0: length 97.7
  TOP w0.132: v1(176.47,72.94) 174.46,72.94 165.43,81.97 165.43,88.83 163.95,90.32 162.51,90.32 161.44,91.39 158.36,91.39 U34.B22
  L03_SIG1 w0.084: J19.1 172.8,23.41 184.2,23.41 184.91,24.13 184.91,26.8 182.56,29.15 182.56,62.61 177.6,67.58 177.6,71.81 v1(176.47,72.94)
TIMER_IO1: length 76.5
  TOP w0.132: U34.C23 v1(157.56,90.59)
  L03_SIG1 w0.084: J19.2 175.37,27.16 175.37,31.47 175.32,31.51 175.32,36.01 170.38,40.94 170.38,47.81 170.99,48.42 170.99,51.01 170.38,51.61 170.38,60.04 167.35,63.08 167.35,84.1 160.86,90.59 v1(157.56,90.59)
TIMER_IO2: length 47.9
  TOP w0.132: RA6.1 v1(169.59,65.79)
  L03_SIG1 w0.084: J19.3 176.02,25.27 178.55,27.8 178.55,33.11 170.64,41.02 170.64,47.73 171.23,48.32 171.23,51.23 170.64,51.82 170.64,60.17 168.83,61.98 168.83,65.03 v1(169.59,65.79)
TIMER_IO3: length 47.1
  TOP w0.132: v1(169.55,64.26) 170.15,64.86 RA6.2
  L03_SIG1 w0.084: v1(169.55,64.26) 170.87,62.93 170.87,51.92 171.47,51.33 171.47,48.23 170.87,47.64 170.87,41.19 179.2,32.87 179.2,27.05 178.56,26.42 J19.4
TIMER_IO6: length 47.3
  TOP w0.132: RA6.3 v1(170.65,65.53)
  L03_SIG1 w0.084: v1(170.65,65.53) 170.19,65.07 170.19,64 171.11,63.08 171.11,52.05 171.7,51.46 171.7,48.13 171.11,47.54 171.11,41.29 181.1,31.3 J19.5
TIMER_IO7: length 48.2
  TOP w0.132: RA6.4 171.2,64.78 v1(170.69,64.26)
  L03_SIG1 w0.084: v1(170.69,64.26) 171.35,63.6 171.35,52.15 171.96,51.54 171.96,48.04 171.35,47.42 171.35,41.51 181.86,30.99 181.86,27.05 J19.6
TM4C129_RSTN: length 28.6
  TOP w0.132: R323.2 v1(60.81,26.5)
  L03_SIG1 w0.084: v1(55.44,4.66) 56.39,5.61 56.39,14.25 62.04,19.9 62.04,25.28 v1(60.81,26.5)
  BOTTOM w0.132: J40.10 v1(55.44,4.66)
TM4C129_TCK: length 14.1
  BOTTOM w0.132: J40.4 59.25,9.78 60.86,11.4 60.86,17.48 60.56,17.78 59.57,17.78 59.29,17.51 U106.100
TM4C129_TDI: length 13.7
  L03_SIG1 w0.084: v1(57.98,4.66) 59.25,5.93 59.25,14.39 v1(60.09,15.24)
  BOTTOM w0.132: U106.98 v1(60.09,15.24) ; J40.8 v1(57.98,4.66)
TM4C129_TDO: length 13.2
  L03_SIG1 w0.084: v1(60.09,14.03) 60.09,5.08 v1(60.52,4.66)
  BOTTOM w0.132: J40.6 v1(60.52,4.66) ; v1(60.09,14.03) 60.49,14.43 U106.97
TM4C129_TMS: length 11.1
  BOTTOM w0.132: U106.99 59.69,10.92 56.71,7.94 J40.2
TMP1_ADD0: length 2.4
  BOTTOM w0.132: U89.5 R544.2 R547.2
TMP1_ADD1: length 2.6
  BOTTOM w0.132: U89.3 R539.2 R526.2
TMP2_ADD0: length 2.6
  TOP w0.132: R247.1 R256.2 U44.5
TMP2_ADD1: length 2.7
  TOP w0.132: U44.3 R261.2 R255.2
USB0_ATEST: length 22.8
  TOP w0.132: U34.AD10 v1(139.96,101.79)
  L05_SIG2 w0.084: v1(121.48,103.5) 122.87,102.11 137.41,102.11 138.14,101.38 139.55,101.38 v1(139.96,101.79)
  BOTTOM w0.132: TP54.1 121.48,102.36 v1(121.48,103.5)
USB0_DM: length 45.5
  TOP w0.104: U34.AE2 v1(139.16,108.19) ; J5.36 153.74,144.84 153.44,144.54 153.44,143.45 v1(153.8,143.1)
  L12_SIG4 w0.089: v1(139.16,108.19) 138.73,108.62 138.73,109.06 138.76,109.08 138.76,111.6 138.05,112.31 138.05,114.78 138.72,115.46 138.72,117.74 140.45,119.47 140.45,128.72 153.57,141.84 153.57,142.87 v1(153.8,143.1)
USB0_DP: length 45.4
  TOP w0.104: U34.AF1 v1(138.36,108.99) ; J5.37 152.94,144.84 153.23,144.55 153.23,143.44 v1(152.88,143.1)
  L12_SIG4 w0.089: v1(138.36,108.99) 138.54,109.17 138.54,111.51 137.83,112.22 137.83,114.87 138.51,115.55 138.51,117.83 140.23,119.56 140.23,128.81 153.35,141.93 153.35,143.31 153.25,143.41 153,143.41 152.88,143.29 v1(152.88,143.1)
USB0_DRV_VBUS: length 64.2
  TOP w0.132: J5.5 154.54,149.66 154.75,149.87 v1(154.75,152.3) ; U34.AD9 v1(139.96,102.59)
  L12_SIG4 w0.084: v1(139.96,102.59) 139.96,102.87 139.59,103.24 139.59,103.24 139.53,103.3 139.53,104.28 139.86,104.62 140.91,104.62 141.13,104.84 141.13,109.38 142.01,110.26 142.01,113.9 141.35,114.55 141.35,117.86 141.61,118.11 141.61,123.83 146.56,128.78 146.56,132.92 148.11,134.48 148.57,134.48 156.59,142.49 156.59,143.76 156.34,144.02 155.96,144.02 154.75,145.22 v1(154.75,152.3)
USB0_ID_SOC: length 60.2
  TOP w0.132: v1(148.14,150.46) 147.34,149.66 J5.14 ; U34.AF7 v1(138.36,104.19)
  L12_SIG4 w0.084: v1(138.36,104.19) 138.75,104.58 139.38,104.58 139.56,104.77 139.56,109.21 139.95,109.6 140.46,109.6 141.35,110.49 141.35,112.14 140.84,112.65 140.84,118.24 141.13,118.53 141.13,124.02 146.09,128.97 146.09,133.12 147.92,134.95 148.33,134.95 154.56,141.18 154.56,143.76 149.23,149.1 149.23,149.37 v1(148.14,150.46)
USB0_PCIE0_SGMII0_RXN0: length 55
  TOP w0.132: 136.47,107.1 136.49,107.12 136.85,107.12 136.85,107.12 arc(137.01,107.09) U34.AH3
  TOP w0.267: J5.40 150.54,144.96 arc(150.56,144.79) 150.63,144.62 arc(150.71,144.5) 150.74,144.35 150.74,135.64 arc(150.6,134.9) 150.18,134.28 148.92,133.02 arc(147.16,131.84) 145.09,131.43 139.5,131.43 arc(138.78,131.29) 138.18,130.89 132.07,124.78 arc(131.43,123.82) 131.2,122.69 131.2,112.47 arc(131.43,111.36) 132.06,110.42 132.99,109.48 132.99,109.22 133.38,108.84 133.63,108.84 133.99,108.49 133.99,108.25 134.29,107.95 134.52,107.95 134.6,107.87 arc(135.45,107.3) 136.47,107.1
USB0_PCIE0_SGMII0_RXP0: length 55.1
  TOP w0.132: 136.49,107.49 136.65,107.49 136.75,107.39 137.47,107.39 arc(137.55,107.41) 137.62,107.46 U34.AG2
  TOP w0.267: 136.49,107.49 136.47,107.49 arc(135.61,107.66) 134.87,108.15 132.33,110.69 arc(131.79,111.51) 131.6,112.47 131.6,122.69 arc(131.79,123.67) 132.35,124.5 138.46,130.61 arc(138.93,130.93) 139.5,131.04 145.09,131.04 arc(147.31,131.48) 149.2,132.74 150.46,134 arc(150.96,134.75) 151.14,135.64 151.14,144.35 arc(151.16,144.5) 151.25,144.62 arc(151.32,144.79) 151.34,144.96 J5.39
USB0_PCIE0_SGMII0_TXN0: length 4.3
  TOP w0.267: J5.43 148.14,144.96 arc(148.16,144.79) 148.23,144.62 arc(148.31,144.5) 148.34,144.35 148.34,142.3 arc(148.27,141.95) C60.2
USB0_PCIE0_SGMII0_TXN0_C: length 52.3
  TOP w0.132: 136.49,106.21 137.14,106.21 U34.AH4
  TOP w0.267: 136.49,106.21 136.33,106.21 136.17,106.05 135.71,106.05 135.55,106.21 135.19,106.21 135,106.02 134.52,106.02 134.33,106.21 134.18,106.21 arc(133.38,106.37) 132.7,106.82 129.12,110.4 arc(128.78,110.91) 128.66,111.51 128.66,122.86 arc(128.95,124.3) 129.77,125.53 138.49,134.24 arc(138.97,134.57) 139.55,134.68 145.29,134.68 arc(145.72,134.77) 146.09,135.01 147.95,136.87 arc(148.24,137.31) 148.34,137.82 148.34,140.07 arc(148.27,140.42) C60.1
USB0_PCIE0_SGMII0_TXP0: length 4.3
  TOP w0.267: J5.42 148.94,144.96 arc(148.92,144.79) 148.85,144.62 arc(148.76,144.5) 148.74,144.35 148.74,142.3 arc(148.81,141.95) C61.2
USB0_PCIE0_SGMII0_TXP0_C: length 52.3
  TOP w0.132: U34.AG3 137.75,106.78 arc(137.53,106.64) 137.28,106.59 136.5,106.59 136.49,106.6
  TOP w0.267: 136.49,106.6 134.18,106.6 arc(133.53,106.73) 132.98,107.1 129.4,110.68 arc(129.15,111.06) 129.06,111.51 129.06,122.86 arc(129.31,124.15) 130.05,125.25 138.77,133.97 arc(139.13,134.21) 139.55,134.29 145.29,134.29 arc(145.88,134.41) 146.37,134.73 148.23,136.59 arc(148.6,137.16) 148.74,137.82 148.74,140.07 arc(148.81,140.42) C61.1
USB0_RESREF: length 19.6
  TOP w0.132: U34.AC9 v1(140.76,102.59)
  L10_SIG3 w0.084: v1(124.73,97.03) 126.81,99.11 129.27,99.11 131.54,101.38 136.14,101.38 136.96,102.2 140.36,102.2 v1(140.76,102.59)
  BOTTOM w0.132: R483.1 v1(124.73,97.03)
USB0_VBUS: length 5.3
  TOP w0.132: J5.47 144.94,144.26 v1(144.66,143.98)
  BOTTOM w0.132: v1(144.66,143.98) 145.18,144.5 R380.1 145.48,144.9 145.11,145.26 144.07,145.26 C691.1
USB0_VBUS_SOC: length 18
  TOP w0.132: U34.AE7 v1(139.16,104.19)
  L10_SIG3 w0.084: v1(124.73,101.09) 128.27,101.09 129.41,102.23 135.8,102.23 137.35,103.78 138.75,103.78 v1(139.16,104.19)
  BOTTOM w0.132: v1(124.73,101.09) R469.2 R471.1
USB1_AB_DM: length 12.6
  TOP w0.104: J3.2 12.02,159.12 12.1,159.19 13.63,159.19 v1(13.89,158.93) 14.19,159.23 14.45,159.23 14.49,159.19 U4.2
  BOTTOM w0.104: FL8.4 17.05,159.28 16.76,158.98 16.5,158.98 14.87,160.62 12.57,160.62 12.19,160.24 12.19,159.56 12.57,159.18 13.64,159.18 v1(13.89,158.93)
USB1_AB_DP: length 12.6
  TOP w0.104: U4.1 14.5,159.69 14.41,159.6 14.24,159.6 v1(13.89,159.95) 13.89,159.69 13.61,159.41 12.22,159.41 11.86,159.77 J3.3
  BOTTOM w0.104: FL8.3 17.05,158.48 16.76,158.77 16.41,158.77 14.78,160.4 12.66,160.4 12.41,160.15 12.41,159.65 12.66,159.4 13.65,159.4 13.89,159.64 v1(13.89,159.95)
USB1_AB_ID: length 214.6
  TOP w0.132: U4.3 14.76,158.22 v1(14.66,158.12) ; J3.4 12.59,160.42 v1(13.27,161.1) ; U34.AF5 v1(138.36,105.79)
  L05_SIG2 w0.084: v1(13.27,161.1) 13.65,161.1 14.66,160.1 v1(14.66,158.12) 14.66,155.08 17.34,152.4 26.1,152.4 26.64,151.85 111.21,151.85 111.57,152.21 114.98,152.21 120.45,157.68 137.46,157.68 140.42,154.72 141.33,154.72 v1(141.73,155.13)
  L12_SIG4 w0.084: v1(13.27,161.1) 13.75,161.1 15.19,159.67 15.19,151.33 12.83,148.97 9.59,148.97 J4.5 ; v1(138.36,105.79) 138.75,106.18 138.75,107.55 138.52,107.78 138.21,107.78 137.96,108.03 137.96,108.03 137.95,108.05 137.95,109.58 137.45,110.07 137.45,117.27 138.38,118.2 138.38,122 138.2,122.17 138.2,127.93 138.77,128.5 138.77,129.56 142.32,133.11 142.32,148.77 141.34,149.75 141.34,154.73 v1(141.73,155.13)
USB1_CM_DM: length 127.6
  BOTTOM w0.104: FL8.1 19.29,159.28 19.58,158.98 22.82,158.98 23.34,159.51 65.76,159.51 69.89,163.64 99.09,163.64 110.27,152.45 110.27,142.2 115.71,136.77 115.71,132.61 119.24,129.08 121.23,129.08 R397.2
USB1_CM_DP: length 127.6
  BOTTOM w0.104: FL8.2 19.29,158.48 19.58,158.77 22.9,158.77 23.43,159.3 65.85,159.3 69.98,163.42 99,163.42 110.06,152.36 110.06,142.11 115.49,136.68 115.49,132.52 119.15,128.87 121.22,128.87 R400.2
USB1_DM: length 32.6
  TOP w0.104: U34.AD2 v1(139.96,108.19)
  BOTTOM w0.104: v1(139.96,108.19) 139.56,108.59 139.56,110.12 137.19,112.5 137.19,116.57 137.52,116.9 137.52,120.01 135.46,122.07 133.15,122.07 125.68,129.54 v1(122.53,129.54)
USB1_DP: length 32.6
  TOP w0.104: U34.AE1 v1(139.16,108.99)
  BOTTOM w0.104: v1(122.53,128.4) 122.89,128.75 122.89,128.99 123.22,129.32 125.59,129.32 133.06,121.86 135.37,121.86 137.3,119.92 137.3,116.99 136.97,116.66 136.97,112.41 139.34,110.03 139.34,109.64 139.22,109.51 138.9,109.51 138.75,109.36 138.75,109.12 138.87,108.99 v1(139.16,108.99)
USB1_DRV_VBUS: length 20.1
  TOP w0.132: U34.AC8 v1(140.76,103.39)
  L10_SIG3 w0.084: v1(124.73,99.06) 125.77,100.1 129.55,100.1 131.31,101.85 136.07,101.85 137.21,103 140.36,103 v1(140.76,103.39)
  BOTTOM w0.132: v1(124.73,99.06) R474.2 R477.1
USB1_DRVBUS: length 152.3
  TOP w0.132: v1(20.38,146.88) R50.1 U11.4
  L03_SIG1 w0.084: v1(111.82,137.79) 111.82,131.79 111.23,131.19 111.23,127.88 110.73,127.38 110.73,125.8 114.11,122.43 114.11,120.78 115.16,119.72 117.45,119.72 119.15,118.02 119.15,106.81 118.3,105.96 118.3,102.29 v1(122.54,98.04)
  L10_SIG3 w0.084: v1(20.38,146.88) 21.36,147.85 32.08,147.85 36.27,152.04 59.72,152.04 65,146.76 107.37,146.76 108.57,145.56 108.57,145.1 111.82,141.85 v1(111.82,137.79)
  BOTTOM w0.132: R477.2 v1(122.54,98.04)
USB1_HDMI_GPMC_DM: length 152.4
  TOP w0.104: v1(165.83,39.01) 166.01,39.19 166.01,40.6 170.02,44.61 170.02,46.92 168.67,48.27 168.67,60.22 165.51,63.39 164.29,64.6 156.34,64.6 151.5,69.44 120.85,69.44 108.74,81.56 108.74,103.3 111.62,106.18 118.61,106.18 119.61,107.19 119.61,128.22 120.47,129.08 121.23,129.08 R74.1
  BOTTOM w0.104: J35.52 166.04,38.21 166.17,38.34 166.17,38.67 v1(165.83,39.01)
USB1_HDMI_GPMC_DP: length 152.3
  TOP w0.104: v1(166.74,39.01) 166.45,39.01 166.23,39.23 166.23,40.51 170.23,44.52 170.23,47.01 168.88,48.36 168.88,60.31 165.6,63.6 164.38,64.82 156.43,64.82 151.59,69.66 120.94,69.66 108.95,81.65 108.95,103.21 111.71,105.97 118.69,105.97 119.82,107.1 119.82,128.13 120.56,128.87 121.22,128.87 R76.1
  BOTTOM w0.104: J35.54 166.54,38.25 166.38,38.4 166.38,38.65 v1(166.74,39.01)
USB1_HDMI_GPMC_DRVBUS: length 132.6
  L03_SIG1 w0.084: v1(112.46,33.82) 112.1,34.17 112.1,46.75 110.42,48.43 110.42,56.88 113.39,59.84 113.39,92.44 117.17,96.22 122.73,96.22 122.95,96.43 122.95,98.65 v1(122.54,99.06)
  L10_SIG3 w0.084: v1(112.46,33.82) 114.4,31.88 151.19,31.88 152.35,33.03 163.63,33.03 164.94,34.35 164.94,34.84 v1(165.54,35.43)
  BOTTOM w0.132: J35.50 v1(165.54,35.43) ; R474.1 v1(122.54,99.06)
USB1_SHIELD: length 1.4
  TOP w0.254: J3.10 v1(9.87,159.77)
  vias: v1(9.42,164.92) v1(10.44,164.92) v1(10.44,163.91) v1(10.44,162.89)
USB1_VBUS: length 14
  TOP w0.203: 12.41,158.47 12.3,158.58 11.26,158.58 11.15,158.47
  TOP w0.254: 16.03,157.51 16.54,158.01 16.54,159.33 16.18,159.69 U4.6 ; 16.08,156.54 R25.1
  TOP w0.356: J3.1 12.41,158.47
  TOP w0.508: C19.1 12.87,156.91 12.7,156.74 12.7,156.03 12.09,155.42 10.96,155.42 J4.1
UVLO_REF: length 2.7
  TOP w0.132: U14.2 78.05,139.46 R64.1 R68.2
VMAIN: length 169.9
  TOP w0.254: U14.4 v1(77.61,140.76) ; Q2.3 v1(51.81,139.7) ; v1(86.74,92.66) C179.1 87.86,92.43 U35.5 ; R200.1 v1(89.93,96.49) ; R9.1 v1(21.87,169.19) ; R68.1 78.91,136.93
  TOP w0.381: U14.1 76.43,137.06 C69.1
  L03_SIG1 w0.254: v1(61.98,141.6) 60.07,139.7 v1(51.81,139.7) 51.81,145.07 42.67,154.2 35.41,154.2 v1(34.75,153.54)
  L05_SIG2 w0.254: v1(103.25,146.3) 105.41,146.3 106.72,145 v1(106.72,140.46) ; v1(107.52,134.6) 106.72,135.4 v1(106.72,140.46) ; v1(106.72,140.46) 105.57,139.32 101.6,139.32 98.93,136.65 80.26,136.65 v1(78.93,135.32)
  L10_SIG3 w0.254: v1(34.75,153.54) 33.97,154.32 33.97,157.08 v1(21.87,169.19)
  L12_SIG4 w0.254: v1(78.93,130.24) 78.93,110.68 89.93,99.68 v1(89.93,96.49) 86.74,93.3 v1(86.74,92.66)
  BOTTOM w0.254: R359.1 v1(34.75,153.54) ; v1(107.52,134.6) 107.25,134.87 U75.40 ; U75.31 106.41,139.37 C323.1 v1(106.72,140.46)
  BOTTOM w0.305: v1(103.25,146.3) 102.62,145.67 102.62,143.51 102.87,143.26 103.72,143.26 C340.1 103.76,142.42 102.87,141.53 102.87,140.98 102.95,140.9 U75.25
  vias: v1(61.98,140.59) v1(61.98,139.57) v1(61.98,138.56) v1(61.98,137.54) v1(61.98,136.53) v1(62.99,141.6) v1(62.99,140.59) v1(62.99,139.57) v1(62.99,138.56) v1(62.99,137.54) v1(62.99,136.53) v1(64.01,141.6) v1(64.01,140.59) v1(64.01,139.57) v1(64.01,138.56) v1(64.01,137.54) v1(64.01,136.53) v1(65.02,141.6) v1(65.02,140.59) v1(65.02,139.57) v1(65.02,138.56) v1(65.02,137.54) v1(65.02,136.53) v1(66.03,140.59) v1(66.04,141.6) v1(66.04,139.57) v1(66.04,138.56) v1(66.04,137.54) v1(66.04,136.53) v1(75.88,135.32) v1(75.88,134.3) v1(75.88,133.29) v1(75.88,132.27) v1(75.88,131.25) v1(75.88,130.24) v1(76.9,135.32) v1(76.9,134.3) v1(76.9,133.29) v1(76.9,132.27) v1(76.9,131.25) v1(76.9,130.24) v1(77.91,135.32) v1(77.91,134.3) v1(77.91,133.29) v1(77.91,132.27) v1(77.91,131.25) v1(77.91,130.24) v1(78.93,134.3) v1(78.93,133.29) v1(78.93,132.27) v1(78.93,131.25)
VOUT1_DATA20: length 73.4
  TOP w0.132: U34.T28 v1(146.36,86.59)
  L03_SIG1 w0.084: v1(146.36,86.59) 146.36,76.86 145.16,75.66 145.16,66.85 146.5,65.51 146.5,57.53 141.41,52.44 141.41,50.55 136.37,45.5 136.37,42.41 v1(136.86,41.92)
  L10_SIG3 w0.084: v1(155.04,44.32) 150.67,39.95 138.24,39.95 136.86,41.34 v1(136.86,41.92)
  BOTTOM w0.132: v1(155.04,44.32) J35.7
VOUT1_DATA21: length 34.8
  TOP w0.132: RA6.8 v1(169.59,69.16) ; U34.P23 v1(148.76,90.59)
  L05_SIG2 w0.084: v1(148.76,90.59) 149.16,90.18 150.52,90.18 150.76,89.94 150.76,89.25 151.56,88.45 151.56,86.62 156.82,81.37 156.82,80.1 158.92,78 162.23,78 168.98,71.25 168.98,69.77 v1(169.59,69.16)
  BOTTOM w0.132: RA6.8 v1(169.59,69.16)
VOUT1_DATA21_TEST_HDR: length 37.4
  L12_SIG4 w0.084: v1(165.93,59.55) 166.38,60.01 167.27,60.01 167.54,59.74 167.54,58.57 165.81,56.85 160.08,56.85 154.04,50.8 v1(154.04,45.24)
  BOTTOM w0.132: J35.5 154.54,44.74 v1(154.04,45.24) ; RA17.4 169.59,66.69 165.93,63.03 v1(165.93,59.55)
VOUT1_DATA22: length 55.2
  TOP w0.132: U34.R26 v1(147.16,88.19)
  L03_SIG1 w0.084: v1(154.04,44.32) 153.41,44.95 153.41,45.39 153.16,45.64 153.16,54.41 153.72,54.97 153.72,80.06 152.74,81.04 152.74,87.54 150.89,89.4 149.39,89.4 149.16,89.63 149.16,89.93 148.92,90.18 148.35,90.18 147.55,89.38 146.99,89.38 146.76,89.15 146.76,88.58 v1(147.16,88.19)
  BOTTOM w0.132: J35.3 v1(154.04,44.32)
VOUT1_DATA23: length 40.1
  TOP w0.132: U34.R23 v1(147.16,90.59) ; v1(169.59,70.08) 170.15,69.52 RA6.7
  L05_SIG2 w0.084: v1(169.59,70.08) 169.59,71.08 162.32,78.35 160.51,78.35 157.89,80.97 157.89,82.09 155.45,84.53 155.45,85.63 154.83,86.25 154.83,88.33 154.57,88.6 153.36,88.6 152.35,89.61 152.35,89.95 152.12,90.18 151.79,90.18 151.55,90.43 151.55,90.75 151.3,91 150.99,91 150.75,91.25 150.75,91.55 150.52,91.78 148.35,91.78 147.93,91.37 147.93,90.98 147.55,90.59 v1(147.16,90.59)
  BOTTOM w0.132: v1(169.59,70.08) 170.15,69.52 RA6.7
VOUT1_DATA23_TEST_HDR: length 35.2
  L12_SIG4 w0.084: v1(167.08,59.55) 167.08,58.55 165.76,57.23 160.03,57.23 153.04,50.23 v1(153.04,45.24)
  BOTTOM w0.132: J35.1 153.54,44.74 v1(153.04,45.24) ; v1(167.08,59.55) 167.08,62.49 170.15,65.55 RA17.3
VOUT1_DE: length 45.4
  TOP w0.132: RA6.5 171.2,69.52 v1(170.65,70.08) ; U34.T23 v1(146.36,90.59)
  L05_SIG2 w0.084: v1(146.36,90.59) 146.36,90.84 146.75,91.23 146.75,93.2 146.93,93.38 152.12,93.38 152.35,93.15 152.35,91.16 152.51,91 152.95,91 153.15,90.8 153.15,90.75 153.15,90.75 153.15,90.33 153.28,90.2 155.3,90.2 155.55,89.95 155.55,86.41 156.06,85.9 156.06,84.78 161.88,78.96 162.58,78.96 170.65,70.88 v1(170.65,70.08)
  BOTTOM w0.132: v1(170.65,70.08) 171.2,69.52 RA6.5
VOUT1_DE_TEST_HDR: length 40.8
  L03_SIG1 w0.084: v1(159.54,34.52) 160.08,35.06 160.08,35.94 163.51,39.37 163.51,49.31 168.99,54.79 168.99,59.17 v1(169.37,59.55)
  BOTTOM w0.132: RA17.1 171.2,66.77 171.7,66.27 171.7,61.88 v1(169.37,59.55) ; J35.28 160.04,35.02 v1(159.54,34.52)
VOUT1_HSYNC: length 42.3
  TOP w0.132: U34.T24 v1(146.36,89.79) ; RA6.6 v1(170.65,69.16)
  L05_SIG2 w0.084: v1(146.36,89.79) 146.76,90.2 146.76,90.75 147.01,91 147.32,91 147.57,91.25 147.57,92.33 147.83,92.58 151.35,92.58 151.56,92.37 151.56,91.24 151.81,90.98 152.12,90.98 152.35,90.75 152.35,90.27 152.43,90.18 152.92,90.18 153.15,89.95 153.15,89.65 153.39,89.4 154.91,89.4 155.24,89.07 155.24,86.26 155.75,85.75 155.75,84.65 161.76,78.65 162.45,78.65 170.24,70.86 170.24,69.57 v1(170.65,69.16)
  BOTTOM w0.132: RA6.6 v1(170.65,69.16)
VOUT1_HSYNC_TEST_HDR: length 38.9
  L03_SIG1 w0.084: v1(168.23,59.55) 168.63,59.15 168.63,54.81 162.58,48.76 162.58,39.2 159.54,36.16 v1(159.54,35.43)
  BOTTOM w0.132: RA17.2 170.65,66.77 171.2,66.22 171.2,62.52 v1(168.23,59.55) ; J35.26 v1(159.54,35.43)
VOUT1_PCLK: length 101.4
  TOP w0.132: U34.R24 v1(147.16,89.79)
  L03_SIG1 w0.084: v1(136.86,43.83) 138.17,42.52 138.17,41.67 137.6,41.1 135.71,41.1 134.38,42.43 134.38,50.52 134.38,50.95 137.74,54.32 141.57,54.32 144.68,57.42 144.68,65.61 142.18,68.11 142.18,82.11 144.97,84.9 144.97,86.17 145.16,86.36 145.16,89.95 145.39,90.18 146.76,90.18 v1(147.16,89.79)
  L10_SIG3 w0.084: v1(157.54,34.52) 153.32,38.73 136.65,38.73 134.11,41.27 134.11,43.94 134.81,44.64 136.05,44.64 v1(136.86,43.83)
  BOTTOM w0.132: J35.20 158.04,35.02 v1(157.54,34.52)
VOUT1_VSYNC: length 85.9
  TOP w0.132: U34.T25 v1(146.36,88.99)
  L03_SIG1 w0.084: v1(146.36,88.99) 145.96,88.59 145.96,76.89 144.11,75.04 144.11,67.47 145.59,65.99 145.59,57.04 141.92,53.38 138.02,53.38 135.8,51.16 v1(135.8,43.88)
  L10_SIG3 w0.084: v1(158.54,34.52) 157.94,35.11 157.94,35.6 154.2,39.34 136.9,39.34 134.94,41.31 134.94,43.01 v1(135.8,43.88)
  BOTTOM w0.132: J35.24 159.04,35.02 v1(158.54,34.52)
VOUT_D0_BOOTMODE0: length 120.2
  TOP w0.132: U34.M27 149.55,87.39 149.55,84.64 v1(150.3,83.88) ; v1(166.04,44.32) 166.38,44.66 166.38,47.38 166.12,47.64 164.67,47.64 164.04,47.01 161.97,47.01 161.79,46.82 146.55,46.82 145.22,48.15 137.9,48.15 137.18,47.43 126.46,47.43 v1(126.03,47.87) 126.62,48.46 126.62,53.02 v1(127.64,54.04) SW3.1 R297.1
  L05_SIG2 w0.084: v1(150.3,83.88) 152.15,83.88 154.93,81.1 154.93,73.08 152.26,70.41 131.43,70.41 126.64,65.62 126.64,63.35 127.62,62.37 127.94,62.37 128.89,61.42 128.89,55.3 v1(127.64,54.04)
  BOTTOM w0.132: R631.1 v1(126.03,47.87) ; J35.51 v1(166.04,44.32)
VOUT_D1_BOOTMODE1: length 121.6
  TOP w0.132: U34.M23 v1(150.36,90.59) ; v1(165.54,45.15) 165.54,45.79 165.35,45.97 165.35,46.37 164.98,46.74 162.08,46.74 161.9,46.56 146.15,46.56 145.47,47.24 137.37,47.24 137.11,46.99 126.05,46.99 125.54,47.5 125.54,48.01 126.03,48.5 v1(126.03,50.15) 126.03,53.69 v1(127.65,55.31) SW3.2 R293.1
  L05_SIG2 w0.084: v1(127.65,55.31) 125.11,57.84 125.11,66.25 131.49,72.62 151.67,72.62 152.12,73.08 152.12,76.6 148.04,80.68 148.04,86.78 147.55,87.28 147.55,89.93 148.59,90.98 149.96,90.98 v1(150.36,90.59)
  BOTTOM w0.132: J35.49 v1(165.54,45.15) ; R626.1 v1(126.03,50.15)
VOUT_D2_BOOTMODE2: length 115.2
  TOP w0.132: R287.1 SW3.3 v1(127.65,56.58) 125.54,54.47 125.54,48.38 125.03,47.87 v1(125.03,47.87) 125.03,47.42 126.15,46.3 162.01,46.3 162.19,46.48 163.9,46.48 165.04,45.34 v1(165.04,44.32) ; v1(150.94,83.19) 150.94,84.01 149.96,84.99 U34.M28
  L05_SIG2 w0.084: v1(127.65,56.58) 128.59,57.52 128.59,61.29 127.82,62.06 127.49,62.06 126.33,63.23 126.33,65.75 131.3,70.71 151.77,70.71 153.86,72.8 153.86,81.01 151.69,83.19 v1(150.94,83.19)
  BOTTOM w0.132: J35.47 v1(165.04,44.32) ; R632.1 v1(125.03,47.87)
VOUT_D3_BOOTMODE3: length 119.4
  TOP w0.132: R282.1 SW3.4 v1(127.65,57.85) 125.03,55.23 v1(125.03,50.15) 125.03,48.5 124.47,47.95 124.47,47.42 125.86,46.03 162.12,46.03 162.3,46.21 163.79,46.21 164.39,45.62 v1(164.39,45.17) ; U34.M24 v1(150.36,89.79)
  L05_SIG2 w0.084: v1(127.65,57.85) 125.42,60.08 125.42,66.12 130.92,71.63 151.46,71.63 152.36,72.53 152.36,77.61 151.66,78.31 151.59,78.31 148.35,81.55 148.35,89.15 148.59,89.39 149.74,89.39 149.95,89.6 150.17,89.6 v1(150.36,89.79)
  BOTTOM w0.132: v1(164.39,45.17) 164.54,45.02 J35.45 ; R627.1 v1(125.03,50.15)
VOUT_D4_BOOTMODE4: length 111.5
  TOP w0.132: R278.1 SW3.5 v1(127.65,59.12) 124.47,55.95 124.47,48.76 124.03,48.31 v1(124.03,47.87) 124.03,47.42 125.68,45.77 162.23,45.77 162.41,45.95 163.39,45.95 163.89,45.45 163.89,44.83 164.04,44.69 v1(164.04,44.32) ; U34.N24 v1(149.56,89.79)
  L03_SIG1 w0.084: v1(127.65,59.12) 126.68,60.08 126.68,71.31 135.76,80.39 138.94,80.39 143.55,85 143.55,91.52 143.56,91.54 143.56,91.55 143.79,91.78 149.72,91.78 149.95,91.55 149.95,90.18 v1(149.56,89.79)
  BOTTOM w0.132: J35.43 v1(164.04,44.32) ; R633.1 v1(124.03,47.87)
VOUT_D5_BOOTMODE5: length 121.8
  TOP w0.132: R274.1 SW3.6 v1(127.65,60.39) 124.03,56.77 v1(124.03,50.15) 123.58,49.71 123.58,46.59 124.84,45.34 131.81,45.34 137.76,39.39 151.86,39.39 154.85,42.37 162.05,42.37 162.59,42.91 162.59,44.79 v1(163.04,45.24) ; U34.N27 v1(148.76,87.39)
  L05_SIG2 w0.084: v1(127.65,60.39) 126.03,62.01 126.03,65.87 131.17,71.02 151.64,71.02 152.83,72.21 152.83,75.95 153.56,76.67 153.56,79.7 149.16,84.1 149.16,86.99 v1(148.76,87.39)
  BOTTOM w0.132: v1(163.04,45.24) 163.54,44.74 J35.41 ; R628.1 v1(124.03,50.15)
VOUT_D6_BOOTMODE6: length 124.9
  TOP w0.132: R260.1 SW3.7 v1(127.65,61.66) 122.53,56.54 v1(122.53,50.15) 123,49.68 123,46.8 124.73,45.07 131.7,45.07 137.65,39.13 151.97,39.13 154.96,42.11 162.16,42.11 163.04,42.99 v1(163.04,44.32) ; U34.N28 v1(148.76,86.59)
  L05_SIG2 w0.084: v1(148.76,86.59) 148.76,84.07 153.22,79.61 153.22,76.86 152.6,76.24 152.6,72.4 151.52,71.32 131.05,71.32 125.72,66 125.72,61.41 127.26,59.86 127.99,59.86 128.16,60.03 128.16,61.14 v1(127.65,61.66)
  BOTTOM w0.132: R629.1 v1(122.53,50.15) ; J35.39 v1(163.04,44.32)
VOUT_D7_BOOTMODE7: length 130.5
  TOP w0.132: R251.1 SW3.8 v1(127.65,62.93) 122.08,57.36 122.08,48.31 v1(122.53,47.87) 122.53,46.51 124.23,44.81 131.59,44.81 137.54,38.86 152.08,38.86 155.07,41.85 162.05,41.85 162.27,41.85 163.51,43.09 163.51,45.39 163.22,45.68 162.52,45.68 162.34,45.5 162.31,45.5 162.04,45.24 v1(162.04,45.24) ; U34.M25 v1(149.56,88.99)
  L05_SIG2 w0.084: v1(149.56,88.99) 149.16,88.6 149.16,87.82 149.48,87.5 149.48,86.23 150.5,85.22 151.24,85.22 155.87,80.59 155.87,72.91 153.06,70.1 131.55,70.1 126.94,65.49 126.94,63.63 v1(127.65,62.93)
  BOTTOM w0.132: J35.37 162.54,44.74 v1(162.04,45.24) ; R634.1 v1(122.53,47.87)
VOUT_D8_BOOTMODE8: length 106.8
  TOP w0.132: v1(127.65,64.2) SW3.9 R245.1 ; v1(161.04,45.24) 161.59,44.68 161.59,43.8 160.43,42.64 154.74,42.64 151.75,39.65 145.26,39.65 143.08,41.83 v1(141.27,41.83) ; U34.N23 v1(149.56,90.59)
  L03_SIG1 w0.084: v1(141.27,41.83) 139.61,40.18 135.33,40.18 129.49,46.02 129.49,62.36 v1(127.65,64.2) 127.19,64.66 127.19,71.06 136.02,79.88 139.07,79.88 144.35,85.16 144.35,90.75 144.59,91 149.15,91 v1(149.56,90.59)
  BOTTOM w0.132: v1(161.04,45.24) 161.54,44.74 J35.33 ; R642.1 v1(141.27,41.83)
VOUT_D9_BOOTMODE9: length 121.7
  TOP w0.132: U34.M26 v1(149.56,88.19) ; v1(127.65,65.47) SW3.10 R240.1
  L03_SIG1 w0.084: v1(127.65,65.47) 129.79,63.32 129.79,46.15 135.46,40.49 138.61,40.49 139.81,41.69 139.81,42.28 v1(141.27,43.74)
  L05_SIG2 w0.084: v1(127.65,65.47) 131.98,69.8 153.19,69.8 155.99,72.61 156.17,72.78 156.17,80.47 156.17,80.72 151.29,85.6 150.56,85.6 149.83,86.32 149.83,87.91 v1(149.56,88.19) ; v1(141.27,43.74) 140.75,44.26 139.03,44.26 138.81,44.04 138.81,43.24 139.7,42.35 142.39,42.35 145.31,39.43 156.6,39.43 161.04,43.87 v1(161.04,44.32)
  BOTTOM w0.132: J35.31 v1(161.04,44.32) ; R635.1 v1(141.27,43.74)
VOUT_D10_BOOTMODE10: length 83
  TOP w0.132: U34.P28 148.08,86.71 148.08,84.08 v1(150.3,81.85) ; SW2.1 v1(148.32,54.05) R295.1 ; v1(140.27,41.83) 140.72,42.29 142.99,42.29 145.37,39.92 151.64,39.92 154.63,42.9 160.06,42.9 160.48,43.33 160.48,44.79 v1(160.04,45.24)
  L03_SIG1 w0.084: v1(150.3,81.85) 152.17,79.99 152.17,57.89 v1(148.32,54.05)
  L12_SIG4 w0.084: v1(140.27,41.83) 143.83,45.39 143.83,48.32 145.11,49.61 145.11,52.78 146.38,54.05 v1(148.32,54.05)
  BOTTOM w0.132: R643.1 v1(140.27,41.83) ; J35.29 160.54,44.74 v1(160.04,45.24)
VOUT_D11_BOOTMODE11: length 78.5
  TOP w0.132: SW2.2 147.94,55.32 148.3,54.97 v1(148.34,54.97) 148.69,55.32 R291.1 ; U34.P27 v1(147.96,87.39)
  L03_SIG1 w0.084: v1(147.96,87.39) 147.96,83.55 148.51,82.99 148.51,76.59 149.25,75.86 149.25,72.8 147.75,71.3 147.75,62.73 148.25,62.23 148.46,62.23 148.84,61.85 148.84,59.53 148.42,59.11 148.08,59.11 147.26,58.28 147.26,56.05 v1(148.34,54.97)
  L05_SIG2 w0.084: v1(140.27,43.74) 141.04,42.96 142.64,42.96 145.01,40.59 156.3,40.59 v1(160.04,44.32)
  L12_SIG4 w0.084: v1(140.27,43.74) 142.75,46.23 142.75,48.1 144.72,50.07 144.72,53.02 146.66,54.97 v1(148.34,54.97)
  BOTTOM w0.132: R636.1 v1(140.27,43.74) ; J35.27 v1(160.04,44.32)
