# Allegro board PROC062E4_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_DQ29: length 35.1
  TOP w0.208: U34.B16 v1(158.36,96.19) ; U33.D8 v1(182.81,101.61)
  L10_SIG3 w0.127: v1(182.81,101.61) 183.22,101.2 183.22,100.64 183.45,100.41 183.45,99.63 183.33,99.51 182.64,99.51 182.52,99.63 182.52,100.24 182.4,100.36 181.72,100.36 181.6,100.24 181.6,99.63 181.48,99.51 179.75,99.51 179.58,99.68 179.58,100.1 179.41,100.27 178.69,100.27 178.57,100.15 178.57,98.89 178.11,98.43 171.94,98.43 171.38,97.87 170,97.87 168.89,98.97 163.83,98.97 163.28,98.43 161.81,98.43 161.12,97.74 159.61,97.74 158.3,97.74 157.96,97.4 157.96,96.83 158.36,96.44 v1(158.36,96.19)
DDR_DQ30: length 35.1
  TOP w0.208: U33.E3 v1(183.61,96.81) ; U34.C16 v1(157.56,96.19)
  L10_SIG3 w0.127: v1(157.56,96.19) 157.56,95.94 157.95,95.55 157.95,95.25 158.19,95 159.59,95 160.22,95.63 162.45,95.63 162.89,95.19 166.64,95.19 167.27,95.82 178.26,95.82 179.75,97.31 180.53,97.31 180.82,97.02 180.82,96.64 181.07,96.4 182.16,96.4 182.4,96.64 182.4,97.72 182.63,97.94 184.69,97.94 184.81,97.82 184.81,96.6 184.63,96.41 184.01,96.41 v1(183.61,96.81)
DDR_DQ31: length 35
  TOP w0.208: U34.A17 v1(159.16,95.39) ; U33.E7 v1(183.61,100.81)
  L10_SIG3 w0.127: v1(183.61,100.81) 184,100.41 184.6,100.41 184.76,100.25 184.76,99.03 184.64,98.91 184.05,98.91 183.93,98.79 183.93,98.5 183.81,98.37 183.52,98.37 183.4,98.5 183.4,98.79 183.28,98.91 182.99,98.91 182.87,98.79 182.87,98.5 182.75,98.37 182.47,98.37 182.34,98.5 182.34,98.79 182.22,98.91 179.11,98.91 178.26,98.06 172.09,98.06 171.53,97.5 169.85,97.5 168.81,98.54 164.41,98.54 163.24,97.37 159.61,97.37 159.47,97.51 159.12,97.51 158.76,97.15 158.76,95.78 v1(159.16,95.39)
DDR_DQ36: length 34.7
  TOP w0.157: U38.C2 v1(182.01,82.29)
  TOP w0.208: U34.B19 v1(158.36,93.79)
  L12_SIG4 w0.127: v1(158.36,93.79) 159.16,93.79 160.49,92.46 165.85,92.46 167.62,90.69 167.62,89.68 172.35,84.95 172.52,84.95 173.25,85.68 173.43,85.68 173.7,85.41 173.7,85.23 172.97,84.5 172.97,84.33 173.24,84.06 173.42,84.06 174.14,84.79 174.32,84.79 174.59,84.52 174.59,84.34 173.86,83.61 173.86,83.44 174.39,82.91 181.39,82.91 v1(182.01,82.29)
DDR_DQ37: length 34.8
  TOP w0.157: U38.B7 v1(181.21,87.09)
  TOP w0.208: U34.B18 v1(158.36,94.59)
  L12_SIG4 w0.127: v1(158.36,94.59) 158.76,95 159.41,95 160.13,95.72 161.32,95.72 162.48,94.56 171.86,94.56 172.76,93.66 172.76,93.49 172.32,93.05 172.32,92.88 172.59,92.6 172.77,92.6 173.21,93.04 173.38,93.04 173.65,92.77 173.65,92.6 173.21,92.16 173.21,91.98 173.48,91.71 173.66,91.71 174.1,92.15 174.27,92.15 174.54,91.88 174.54,91.71 174.1,91.27 174.1,91.09 174.38,90.82 174.55,90.82 174.99,91.26 175.16,91.26 176.28,90.15 176.28,87.63 177.68,86.23 180.74,86.23 181.21,86.7 v1(181.21,87.09)
DDR_DQ38: length 34.8
  TOP w0.157: U38.D3 v1(182.81,83.09)
  TOP w0.208: U34.C18 v1(157.56,94.59)
  L12_SIG4 w0.127: v1(182.81,83.09) 182.81,84.2 182.17,84.84 176.5,84.84 171.78,89.56 171.78,93.14 170.73,94.2 162.32,94.2 161.27,95.25 160.28,95.25 159.23,94.2 158.19,94.2 157.8,94.59 v1(157.56,94.59)
DDR_DQ39: length 34.9
  TOP w0.157: U38.D7 v1(182.81,87.09)
  TOP w0.208: U34.D18 v1(156.76,94.59)
  L12_SIG4 w0.127: v1(156.76,94.59) 156.36,94.98 156.36,96.37 156.59,96.6 161.47,96.6 161.99,96.09 172.53,96.09 179.45,89.17 181.04,89.17 181.62,88.6 181.62,86.93 181.85,86.7 182.42,86.7 v1(182.81,87.09)
DDR_DQ40: length 34.8
  TOP w0.157: U38.D2 v1(182.81,82.29)
  TOP w0.208: U34.E18 v1(155.96,94.59)
  L12_SIG4 w0.127: v1(155.96,94.59) 156.35,94.2 156.9,94.2 157.16,93.93 157.16,93.63 157.41,93.38 157.72,93.38 157.96,93.13 157.96,92.83 158.19,92.6 158.75,92.6 159.63,91.73 164.27,91.73 174.91,81.09 182.22,81.09 182.42,81.29 182.42,81.65 182.74,81.98 182.74,82.22 v1(182.81,82.29)
DDR_DQ41: length 34.7
  TOP w0.157: U38.D8 v1(182.81,87.89)
  TOP w0.208: U34.E17 v1(155.96,95.39)
  L12_SIG4 w0.127: v1(155.96,95.39) 155.56,95.78 155.56,97.15 155.79,97.38 163.52,97.38 164.38,96.52 172.62,96.52 179.44,89.69 181.72,89.69 182.42,89 182.42,88.28 v1(182.81,87.89)
DDR_DQ42: length 34.8
  TOP w0.157: U38.E3 v1(183.61,83.09)
  TOP w0.208: U34.D17 v1(156.76,95.39)
  L12_SIG4 w0.127: v1(183.61,83.09) 183.21,82.68 182.65,82.68 182.42,82.45 182.42,82.15 182.17,81.9 174.79,81.9 164.6,92.09 160.12,92.09 158.84,93.38 158.21,93.38 157.96,93.63 157.96,93.95 157.72,94.2 157.39,94.2 157.15,94.45 157.15,95 v1(156.76,95.39)
DDR_DQS0_N: length 52.2
  TOP w0.157: U16.B3 v1(181.21,137.95) ; U34.C1 v1(157.56,108.99)
  L12_SIG4 w0.109: v1(181.21,137.95) 181.47,137.95 181.74,138.22 181.74,138.83 181.62,138.95 180.45,138.95 179.35,137.85 179.35,126.19 176.02,122.86 170.04,122.86 166.67,119.49 166.67,119.32 167.01,118.99 167.01,118.65 166.69,118.34 166.34,118.34 166.01,118.67 165.85,118.67 165.67,118.49 165.67,118.32 166,117.98 166,117.63 165.7,117.34 165.33,117.34 165,117.67 164.85,117.67 164.66,117.48 164.66,117.31 165.02,116.96 165.02,116.62 164.7,116.3 164.36,116.3 163.99,116.66 163.84,116.66 163.65,116.47 163.65,116.31 163.94,116.02 163.94,115.67 163.63,115.35 163.29,115.35 162.99,115.65 162.83,115.65 157.08,109.9 157.08,109.21 157.34,108.95 157.52,108.95 v1(157.56,108.99)
DDR_DQS0_P: length 52.2
  TOP w0.157: U16.C3 v1(182.01,137.95) ; U34.D1 v1(156.76,108.99)
  L12_SIG4 w0.109: v1(156.76,108.99) 156.86,109.09 156.86,109.99 162.74,115.88 163.08,115.88 163.38,115.58 163.54,115.58 163.72,115.76 163.72,115.93 163.43,116.22 163.43,116.57 163.75,116.88 164.09,116.88 164.45,116.52 164.6,116.52 164.8,116.71 164.8,116.86 164.44,117.22 164.44,117.57 164.75,117.89 165.09,117.89 165.42,117.56 165.61,117.56 165.78,117.72 165.78,117.89 165.45,118.23 165.45,118.58 165.76,118.89 166.1,118.89 166.43,118.56 166.6,118.56 166.78,118.74 166.78,118.9 166.45,119.23 166.45,119.58 169.95,123.08 175.93,123.08 179.13,126.28 179.13,137.94 180.36,139.17 181.71,139.17 181.96,138.92 181.96,138.01 v1(182.01,137.95)
DDR_DQS1_N: length 50.2
  TOP w0.157: U20.B3 v1(182.01,125.04) ; U34.A4 v1(159.16,106.59)
  L10_SIG3 w0.109: v1(182.01,125.04) 181.7,124.73 178.73,124.73 167.7,113.7 167.4,113.7 167.12,113.97 167.12,114.16 172.31,119.34 172.31,119.7 171.93,120.08 171.55,120.08 165.73,114.26 165.73,113.84 166.66,112.91 166.66,112.56 160.38,106.29 159.45,106.29 v1(159.16,106.59)
DDR_DQS1_P: length 50.1
  TOP w0.157: U20.C3 v1(182.01,124.24) ; U34.A5 v1(159.16,105.79)
  L10_SIG3 w0.109: v1(182.01,124.24) 181.74,124.51 178.82,124.51 167.79,113.47 167.31,113.47 166.9,113.88 166.9,114.25 172.09,119.43 172.09,119.61 171.83,119.86 171.64,119.86 165.95,114.17 165.95,113.93 166.88,113 166.88,112.47 160.48,106.07 159.44,106.07 v1(159.16,105.79)
DDR_DQS2_N: length 37.5
  TOP w0.157: v1(160.4,100.39) 160.15,100.14 159.8,100.14 159.19,99.54 159.01,99.54 U34.A12 ; U25.B3 v1(182.01,111.32)
  L12_SIG4 w0.109: v1(160.4,100.39) 160.72,100.08 161.05,100.08 161.54,100.57 161.54,101.53 162.02,102.01 167.5,102.01 169.39,103.9 172.42,103.9 174.48,105.97 174.48,106.22 173.93,106.77 173.93,107.21 174.24,107.52 174.68,107.52 175.23,106.97 175.49,106.97 175.67,107.15 175.67,107.41 175.12,107.96 175.12,108.39 175.43,108.7 175.87,108.7 176.42,108.16 176.67,108.16 176.85,108.34 176.85,108.59 176.31,109.14 176.31,109.58 176.62,109.89 177.05,109.89 177.6,109.34 177.86,109.34 178.04,109.52 178.04,109.78 177.49,110.33 177.49,110.76 177.8,111.08 178.24,111.08 178.79,110.53 179.04,110.53 179.55,111.04 181.73,111.04 v1(182.01,111.32)
DDR_DQS2_P: length 37.4
  TOP w0.157: U34.A13 159.01,99.24 159.31,99.24 159.92,99.85 160.15,99.85 v1(160.4,99.59) ; U25.C3 v1(182.01,110.52)
  L12_SIG4 w0.109: v1(182.01,110.52) 181.72,110.82 179.64,110.82 179.14,110.31 178.7,110.31 178.15,110.85 177.89,110.85 177.71,110.67 177.71,110.42 178.26,109.87 178.26,109.43 177.95,109.12 177.51,109.12 176.96,109.67 176.71,109.67 176.53,109.49 176.53,109.23 177.07,108.68 177.07,108.25 176.76,107.94 176.33,107.94 175.78,108.48 175.52,108.48 175.34,108.3 175.34,108.05 175.89,107.5 175.89,107.06 175.58,106.75 175.14,106.75 174.59,107.3 174.34,107.3 174.16,107.12 174.16,106.86 174.7,106.31 174.7,105.87 172.51,103.68 169.48,103.68 167.59,101.79 162.12,101.79 161.76,101.44 161.76,100.47 161.15,99.86 160.66,99.86 v1(160.4,99.59)
DDR_DQS3_N: length 35
  TOP w0.157: U33.B3 v1(181.21,96.81) ; U34.A16 v1(159.16,96.19)
  L10_SIG3 w0.109: v1(181.21,96.81) 181.58,97.17 181.58,98.09 181.38,98.29 179.99,98.29 177.99,96.29 176.7,96.29 176.41,96.58 176.41,97.04 176.3,97.15 175.91,97.15 175.79,97.03 175.79,96.55 175.53,96.29 174.98,96.29 174.72,96.55 174.72,97.03 174.6,97.14 174.21,97.14 174.09,97.02 174.09,96.55 173.83,96.29 173.28,96.29 173.02,96.55 173.02,97.02 172.9,97.14 172.52,97.14 172.41,97.03 172.41,96.54 172.16,96.3 172.15,96.3 172.15,96.29 167.02,96.29 166.77,96.54 166.77,97.58 166.65,97.71 166.35,97.71 166.24,97.6 166.24,96.57 165.96,96.29 165.24,96.29 164.92,96.61 164.92,97.49 164.77,97.64 164.46,97.64 164.27,97.45 164.27,96.42 163.96,96.11 160.34,96.11 159.78,96.67 159.37,96.67 159.16,96.46 v1(159.16,96.19)
DDR_DQS3_P: length 35
  TOP w0.157: U34.A15 v1(159.16,96.99) ; U33.C3 v1(182.01,96.81)
  L10_SIG3 w0.109: v1(159.16,96.99) 159.26,96.89 159.87,96.89 160.43,96.33 163.87,96.33 164.05,96.51 164.05,97.54 164.37,97.86 164.86,97.86 165.14,97.58 165.14,96.7 165.33,96.51 165.87,96.51 166.02,96.66 166.02,97.69 166.26,97.93 166.74,97.93 166.99,97.67 166.99,96.63 167.11,96.52 172.06,96.52 172.06,96.52 172.07,96.52 172.19,96.64 172.19,97.12 172.42,97.36 173,97.36 173.24,97.11 173.24,96.64 173.37,96.51 173.74,96.51 173.87,96.64 173.87,97.11 174.12,97.36 174.7,97.36 174.94,97.12 174.94,96.64 175.07,96.51 175.44,96.51 175.57,96.64 175.57,97.12 175.82,97.37 176.39,97.37 176.63,97.13 176.63,96.67 176.79,96.51 177.9,96.51 179.9,98.51 181.47,98.51 181.8,98.18 181.8,97.02 v1(182.01,96.81)
DDR_DQS_N: length 34.8
  TOP w0.157: U34.A18 159.26,94.48 160.23,94.48 v1(160.27,94.53) ; U38.B3 v1(182.01,83.89)
  L12_SIG4 w0.109: v1(160.27,94.53) 160.58,94.22 161.57,94.22 162.05,93.74 169.38,93.74 169.96,93.15 169.96,90.69 171.16,89.49 171.16,89.05 170.49,88.38 170.49,88.13 170.67,87.95 170.93,87.95 171.6,88.62 172.04,88.62 172.35,88.31 172.35,87.87 171.67,87.2 171.67,86.94 171.85,86.76 172.11,86.76 172.78,87.43 173.22,87.43 177.05,83.6 181.72,83.6 182.01,83.89 v1(182.01,83.89)
DDR_DQS_P: length 34.7
  TOP w0.157: U34.A19 159.81,94.19 v1(160.27,93.73) ; U38.C3 v1(182.01,83.09)
  L12_SIG4 w0.109: v1(182.01,83.09) 181.73,83.38 176.96,83.38 173.13,87.21 172.87,87.21 172.2,86.54 171.76,86.54 171.45,86.85 171.45,87.29 172.12,87.96 172.12,88.21 171.94,88.4 171.69,88.4 171.02,87.73 170.58,87.73 170.27,88.04 170.27,88.48 170.94,89.15 170.94,89.4 169.74,90.6 169.74,93.06 169.29,93.52 161.96,93.52 161.48,94 160.55,94 v1(160.27,93.73)
DDR_ODT: length 149.7
  TOP w0.157: U38.F3 v1(184.41,83.09)
  TOP w0.208: U34.B11 v1(158.36,100.99) ; U16.F3 v1(184.41,137.95) ; U33.F3 v1(184.41,96.81) ; U20.F3 v1(184.41,124.24) ; U25.F3 v1(184.41,110.52)
  L05_SIG2 w0.127: v1(184.41,137.95) 184.41,137.72 184.8,137.33 184.8,136.24 184.2,135.63 183.51,135.63 183.26,135.38 183.26,134.18 183.38,134.05 183.75,134.05 184.01,133.8 184.01,133.41 183.81,133.21 183.32,133.21 183.2,133.09 183.2,126.03 184.41,124.82 v1(184.41,124.24) 184.41,124.01 184.8,123.62 184.8,122.52 184.2,121.92 183.51,121.92 183.26,121.67 183.26,120.46 183.38,120.34 183.75,120.34 184.01,120.08 184.01,119.69 183.81,119.49 183.32,119.49 183.2,119.37 183.2,112.31 184.41,111.1 v1(184.41,110.52) 184.41,110.29 184.8,109.9 184.8,108.81 184.2,108.2 183.51,108.2 183.26,107.95 183.26,106.74 183.38,106.62 183.75,106.62 184,106.37 184,105.97 183.81,105.78 183.32,105.78 183.2,105.65 183.2,98.61 184.41,97.4 v1(184.41,96.81) 184.41,96.58 184.8,96.19 184.8,95.09 184.2,94.49 183.5,94.49 183.26,94.25 183.26,93.03 183.38,92.91 183.75,92.91 184.02,92.64 184.02,92.27 183.81,92.06 183.32,92.06 183.2,91.94 183.2,84.89 184.41,83.69 v1(184.41,83.09) 184.41,82.92 184.8,82.53 184.8,80.24 184.38,79.82 180.27,79.82 179.52,80.56 179.52,99.99 173.66,105.85 169.74,105.85 167.47,108.12 163.46,108.12 163.13,108.46 162.44,108.46 162.11,108.12 160.96,108.12 159.81,106.98 154.99,106.98 154.76,106.76 154.76,104.36 154.76,104.35 154.76,104.03 154.99,103.8 155.31,103.8 155.55,103.55 155.55,100.83 155.78,100.6 156.1,100.6 156.35,100.35 156.35,100.05 156.59,99.8 157.72,99.8 157.95,100.03 157.95,100.58 v1(158.36,100.99)
  BOTTOM w0.208: R377.1 194.65,142.73 194.2,142.28 194.19,142.28 194.18,142.27 192.11,142.27 190.88,141.03 187.49,141.03 v1(184.41,137.95)
DDR_ODT1: length 151.5
  TOP w0.157: U38.F2 v1(184.41,82.29)
  TOP w0.208: U34.E12 v1(155.96,100.19) ; U16.F2 v1(184.41,137.15) ; R56.1 v1(193.98,142.75) ; U20.F2 v1(184.41,123.44) ; U33.F2 v1(184.41,96.01) ; U25.F2 v1(184.41,109.72)
  L05_SIG2 w0.127: v1(193.98,142.75) 192.71,141.48 186.82,141.48 184.02,138.68 184.02,137.55 v1(184.41,137.15) 184.41,136.48 183.9,135.96 182.46,135.96 182,135.51 182,134.36 182.42,133.94 182.42,126.06 184.01,124.47 184.01,123.84 v1(184.41,123.44) 184.41,122.76 183.9,122.25 182.46,122.25 182,121.79 182,120.64 182.42,120.22 182.42,112.35 184.01,110.76 184.01,110.12 v1(184.41,109.72) 184.41,109.05 183.9,108.53 182.43,108.53 182.02,108.11 182.02,106.88 182.42,106.48 182.42,98.63 184.01,97.04 184.01,96.41 v1(184.41,96.01) 184.41,95.33 183.9,94.81 182.36,94.81 182.05,94.51 182.05,93.16 182.42,92.79 182.42,84.92 184.01,83.33 184.01,82.69 v1(184.41,82.29) 184.41,81.24 184.01,80.84 180.89,80.84 179.9,81.83 179.9,101.28 178.82,102.36 178.82,103.76 178.56,104.01 178.56,104.9 178.82,105.16 178.82,105.92 178.31,106.43 169.93,106.43 169.16,107.19 169.16,109.22 168.78,109.6 161.8,109.6 160,107.8 155.01,107.8 154.76,107.55 154.76,107.25 154.52,107 154.21,107 153.96,106.75 153.96,104.36 153.96,104.35 153.96,103.98 154.14,103.8 154.62,103.8 154.75,103.67 154.75,100.77 154.94,100.58 155.32,100.58 155.7,100.2 155.94,100.2 v1(155.96,100.19)
DDR_PARITY: length 142.2
  TOP w0.157: U38.N3 v1(190.81,83.09)
  TOP w0.208: U34.B10 v1(158.36,101.79) ; U20.N3 v1(190.81,124.24) ; U25.N3 v1(190.81,110.52) ; U33.N3 v1(190.81,96.81) ; U16.N3 v1(190.81,137.95)
  L05_SIG2 w0.127: v1(190.81,137.95) 191.23,137.54 192.26,137.54 192.47,137.33 192.47,124.42 192.28,124.24 v1(190.81,124.24) 191.23,123.82 192.26,123.82 192.47,123.62 192.47,110.71 192.28,110.52 v1(190.81,110.52) 191.23,110.11 192.26,110.11 192.47,109.9 192.47,96.98 192.29,96.81 v1(190.81,96.81) 191.23,96.39 192.26,96.39 192.47,96.19 192.47,83.26 192.3,83.09 v1(190.81,83.09) 191.75,82.15 191.75,78.4 188.41,75.06 177.88,75.06 177.66,75.27 171.67,81.27 171.67,83.86 169.3,86.23 169.3,100.34 167.84,101.8 165.66,101.8 165.54,101.68 165.54,101.29 165.66,101.17 167.59,101.17 167.71,101.05 167.71,100.66 167.59,100.54 165.03,100.54 164.91,100.66 164.91,101.68 164.78,101.8 162.06,101.8 161.29,101.03 159.12,101.03 v1(158.36,101.79)
  BOTTOM w0.208: v1(190.81,137.95) 192.6,136.17 194.18,136.17 194.19,136.18 194.2,136.18 194.65,136.64 R391.1
DDR_RESET#: length 127.7
  TOP w0.208: v1(193.48,134.56) 192.53,133.6 189.96,133.6 189.48,134.08 189.48,136.09 U16.L1 ; U20.L1 189.36,122.49 189.36,120.57 190.42,119.51 192.34,119.51 v1(193.48,120.65) ; U33.L1 189.42,94.99 189.42,93.21 190.15,92.49 193.03,92.49 v1(193.4,92.86) ; U38.L1 189.25,81.45 189.25,79.2 189.71,78.75 193.08,78.75 v1(193.42,79.09) R220.1 R219.2 ; R171.1 R165.1 179.45,104.39 180.09,105.03 187.71,105.03 189.55,106.87 ; 189.55,106.87 189.55,108.58 U25.L1 ; 189.55,106.87 190.25,106.17 192.47,106.17 v1(193.36,107.06)
  L03_SIG1 w0.127: v1(193.42,79.09) 193.42,81.55 195.14,83.26 195.14,91.12 v1(193.4,92.86) 195.71,95.17 195.71,104.71 v1(193.36,107.06) 195.45,109.16 195.45,118.68 v1(193.48,120.65) 195.39,122.56 195.39,132.65 v1(193.48,134.56)
DDR_RESET_FS: length 15.4
  TOP w0.132: v1(163.12,102.55) 163.31,102.36 R182.1 R171.2 ; U34.F16 v1(155.16,96.19)
  BOTTOM w0.122: 159.77,96.05 159.52,95.8 155.55,95.8 v1(155.16,96.19)
  BOTTOM w0.132: v1(163.12,102.55) 162.62,102.55 161.8,101.73 161.8,101.24 161.17,100.61 161.17,97.46 159.77,96.05
DDR_TEN: length 65.2
  TOP w0.157: U38.G9 v1(185.21,88.69)
  TOP w0.208: U33.G9 v1(185.21,102.41) ; U20.G9 v1(185.21,129.84) ; U25.G9 v1(185.21,116.12) ; U16.G9 v1(185.21,143.55)
  L12_SIG4 w0.127: v1(185.21,143.55) 185.99,142.77 185.99,130.62 v1(185.21,129.84) 185.91,129.14 185.91,127.42 188.81,124.52 188.81,122.89 189.02,122.68 189.02,119.86 188.41,119.25 188.41,117.83 187.4,116.82 185.91,116.82 v1(185.21,116.12) 186.06,115.28 186.06,108.46 185.67,108.08 185.67,102.87 v1(185.21,102.41) 185.74,101.88 185.74,89.22 v1(185.21,88.69)
  BOTTOM w0.203: v1(185.21,88.69) 185.59,89.06 R503.1
  BOTTOM w0.208: v1(185.21,102.41) 185.21,102.79 185.36,102.93 R462.2
DDR_VPP: length 35.7
  TOP w0.254: v1(182.81,93.98) 182.65,93.82 C173.1 182.21,93.83 181.43,94.61 181.43,95.43 U33.B1 ; v1(194.5,117.16) C104.1 v1(193.48,116.37) ; U16.B1 181.43,136.57 181.43,135.75 182.21,134.98 C79.1 182.64,134.96 182.78,135.1 v1(182.81,135.1) ; v1(193.48,88.94) C181.1 v1(194.5,89.72) ; v1(189.27,89.85) 189.44,90.02 C184.1 189.87,89.51 189.81,89.45 189.81,88.49 U38.M9 ; U33.M9 189.81,102.2 189.81,103.16 189.87,103.23 C141.1 189.44,103.73 v1(189.27,103.57) ; U25.B1 181.43,109.14 181.43,108.39 182.21,107.61 C127.1 182.65,107.59 v1(182.81,107.76) ; U20.B1 181.43,122.86 181.43,122.04 182.21,121.26 C96.1 182.65,121.25 v1(182.81,121.41) ; v1(194.5,103.44) C137.1 v1(193.48,102.65) ; U38.B1 181.43,81.71 181.43,80.89 182.21,80.11 C203.1 182.65,80.1 v1(182.81,80.26) ; v1(189.26,130.94) 189.49,131.17 C88.1 189.86,130.66 189.93,130.58 189.93,129.76 U20.M9 ; U25.M9 189.81,115.92 189.81,116.88 189.87,116.94 C107.1 189.44,117.45 v1(189.27,117.28) ; v1(189.21,144.72) 189.38,144.88 C46.1 189.81,143.35 U16.M9 ; v1(193.48,146.78) C43.1 v1(194.49,145.99) ; v1(193.48,130.09) C85.1 v1(194.5,130.87)
DDR_VREFCA: length 121.8
  TOP w0.203: U10.6 C37.1 v1(205.47,148.78)
  TOP w0.254: R728.1 177.58,118.39 v1(177.8,118.61) ; v1(188.47,135.13) 188.31,134.96 C82.1 187.81,136.15 U16.J1 ; v1(188.47,93.98) 188.31,93.82 C176.1 187.88,94.32 187.81,94.39 187.81,95 U33.J1 ; v1(188.47,107.7) 188.31,107.53 C131.1 187.88,108.04 187.81,108.1 187.81,108.72 U25.J1 ; U20.J1 187.81,122.43 187.81,121.77 187.83,121.76 C99.1 188.31,121.25 v1(188.47,121.41) ; v1(188.41,80.26) 188.41,80.26 188.24,80.1 C206.1 187.81,81.29 U38.J1
  L10_SIG3 w0.122: 188.02,110.97 188.02,109.44 ; 188.02,115.76 188.02,113.92 ; 188.82,129.37 188.82,123.01
  L10_SIG3 w0.203: 188.02,109.44 188.02,108.15 v1(188.47,107.7) ; v1(188.47,135.13) 188.94,134.66 188.94,133.57 188.82,133.45 188.82,129.37 ; 188.02,113.92 188.02,110.97 ; 188.82,123.01 188.82,121.76 v1(188.47,121.41) 188.94,120.95 188.94,119.76 188.02,118.84 188.02,115.76
  L12_SIG4 w0.122: 187.22,81.57 187.22,88.25
  L12_SIG4 w0.203: v1(188.47,107.7) 186.23,105.45 186.23,95.67 187.6,94.3 188.15,94.3 v1(188.47,93.98) 187.5,93.01 187.5,88.53 187.22,88.25 ; v1(188.41,80.26) 187.22,81.46 187.22,81.57
  L12_SIG4 w0.254: v1(177.8,118.61) 178.6,119.41 186.47,119.41 v1(188.47,121.41)
  BOTTOM w0.203: v1(205.47,148.78) 205.42,148.78 200.03,143.38 200.03,134.24 198.88,133.1 194.56,133.1 193.93,132.46 190.63,132.46 189.1,133.99 189.1,134.5 v1(188.47,135.13)
  BOTTOM w0.254: C176.1 188.31,93.82 v1(188.47,93.98) ; v1(188.47,107.7) 188.31,107.53 C131.1 ; C206.1 188.24,80.1 188.41,80.26 v1(188.41,80.26) ; C99.1 188.31,121.25 v1(188.47,121.41) ; v1(188.47,135.13) 188.41,135.13 188.25,134.96 C82.1
DDR_VTT_EN: length 103.1
  TOP w0.132: U34.P3 v1(148.76,107.39)
  L10_SIG3 w0.084: v1(205.9,162.67) 205.29,162.06 205.29,158.81 201.1,154.62 185.36,154.62 171.27,140.54 165.49,140.54 164.27,139.32 163.58,139.32 160.4,136.14 154.05,136.14 151.26,133.35 151.26,128.46 v1(154.11,125.6)
  L12_SIG4 w0.084: v1(148.76,107.39) 148.37,107.78 148.37,109.25 152.08,112.97 152.08,115.89 151.41,116.56 151.41,119.79 153.57,121.95 153.57,125.06 v1(154.11,125.6)
  BOTTOM w0.132: R707.1 205.72,163.3 205.9,163.12 v1(205.9,162.67) 205.46,162.24 205.46,161.5 205.51,161.45 U109.4
DDR_VTT_EN_3V3: length 12.7
  TOP w0.132: 204.72,150.5 204.72,150.07 204.56,149.9 U10.7 ; 204.72,150.5 204.51,150.7 U10.9 ; 204.72,150.5 204.93,150.7 R41.1 v1(205.51,158.13)
  BOTTOM w0.132: U109.9 v1(205.51,158.13) TP84.1
DEBOUNCE_WARM_RST: length 45.3
  TOP w0.132: U52.6 114.52,43.98 112.06,41.53 112.06,38.35 114.25,36.17 120.13,36.17 122.77,33.53 C242.1 R321.1 D13.1 SW7.1 SW7.2 136.06,32.65 136.63,33.22 v1(136.63,33.27)
  BOTTOM w0.132: v1(136.63,33.27) 136.63,32.66 138.73,30.56 144.15,30.56 145,29.7 Q20.2
DEBOUNCE_WKUP_GPIO0_13: length 77.2
  TOP w0.132: SW5.2 SW5.1 D12.1 R320.1 C240.1 ; U52.3 114.52,48.31 114.85,48.64 117.09,48.64 118.69,47.04 118.69,43.62 127.85,34.46 146,34.46 146.68,33.78 153.02,33.78 153.65,33.15 C240.1 ; C240.1 v1(153.65,32.05)
  BOTTOM w0.132: v1(153.65,32.05) 152.73,31.14 148.18,31.14 145.82,28.78 144.07,28.78 143.12,29.73 Q18.2
DEBOUNCE_WKUP_GPIO0_27: length 48.5
  TOP w0.132: C241.1 R318.1 D10.1 SW6.1 SW6.2 ; C241.1 138.14,30.7 v1(137.17,29.73) ; C241.1 138.14,33.31 137.41,34.04 127.9,34.04 118.43,43.51 118.43,46.93 117.09,48.26 115.82,48.26 115.52,47.95 U52.1
  BOTTOM w0.132: Q19.2 v1(137.17,29.73)
DIR: length 68.9
  L05_SIG2 w0.084: v1(142.77,33.85) 142.77,39.1 141.99,39.88 v1(127.53,39.88)
  L12_SIG4 w0.084: v1(140.72,61.66) 140.72,61.2 140.46,60.94 140.46,49.51 139.4,48.45 137.1,48.45 135.03,46.38 135.03,41.64 135.85,40.82 142.06,40.82 143.37,39.51 143.37,34.45 v1(142.77,33.85)
  BOTTOM w0.132: v1(127.53,39.88) 127.03,40.38 U102.2 ; U105.2 142.27,34.35 v1(142.77,33.85) 143.21,33.85 143.43,34.06 R656.1 R648.2 ; U95.2 140.97,61.41 v1(140.72,61.66) 140.97,61.91 U95.3
ECAP0_IN_APWM0_OUT: length 115.5
  TOP w0.132: U34.D21 v1(156.76,92.19)
  L10_SIG3 w0.084: v1(200.51,11.7) 200.09,11.28 200.09,10.35 200.34,10.1 202,10.1 202.08,10.18 202.08,30.7 193.29,39.5 184.09,39.5 180.71,42.87 180.71,73.51 173.43,80.8 167.36,80.8 163.33,84.82 163.33,86.6 158.14,91.8 157.15,91.8 v1(156.76,92.19)
  BOTTOM w0.132: J38.38 v1(200.51,11.7)
EEPROM_A1: length 3.2
  TOP w0.132: U56.2 177.58,17.28 177.4,17.46 R328.2 R327.2
EEPROM_A2: length 3.2
  TOP w0.132: U56.3 178.01,16.63 177.83,16.45 R330.2 R331.2
EEPROM_WP: length 1.6
  TOP w0.132: U56.7 R329.2
EMMC_RSTN: length 10.9
  TOP w0.132: U51.K5 160.95,50.82 v1(160.66,51.12) ; R288.1 U48.4 v1(155.89,54.36)
  BOTTOM w0.132: v1(155.89,54.36) 155.89,52.07 157.29,50.67 160.21,50.67 v1(160.66,51.12)
EXP_BRD_DET_INTN: length 1.8
  TOP w0.132: U46.13 R283.1
EXP_PCIE_DET_INTN: length 80.7
  TOP w0.132: U34.T1 v1(146.36,108.99) ; v1(142.45,157.22) 142.45,156.54 142.89,156.09 U7.13 R27.1
  L12_SIG4 w0.084: v1(142.45,157.22) 142.88,156.78 144.64,156.78 144.67,156.76 144.75,156.76 147.28,154.23 154.57,154.23 154.82,154.48 156.67,154.48 161.58,149.57 161.58,149.3 161.89,148.99 161.89,146.38 160.78,145.27 160.78,137.15 158.99,135.36 152.53,135.36 149.78,132.61 149.78,123.94 145.63,119.79 145.63,117.57 145.25,117.18 145.25,116.29 144.63,115.67 144.63,113.13 145.16,112.59 145.16,108.83 145.39,108.6 145.96,108.6 v1(146.36,108.99)
FB: length 10.1
  TOP w0.203: v1(77.61,143.13) 77.39,143.36 U14.8
  TOP w0.254: v1(78.23,145.41) C48.2 C49.2 79.49,144.73 80.2,145.44 81.69,145.44 81.89,145.24 R53.1 R54.2
  L03_SIG1 w0.203: v1(77.61,143.13) 78.23,143.75 v1(78.23,145.41)
FT4232_DO: length 3
  BOTTOM w0.132: U79.4 25.38,129.5 25.09,129.79 R407.2 24.8,130.44 25.26,130.9 R408.1
FT4232_EECLK: length 8
  BOTTOM w0.132: U79.2 25.29,128.2 25.24,128.14 R413.1 24.8,128.59 24.62,128.78 23.88,128.78 23.37,129.29 23.37,130.45 24.05,131.13 U73.62
FT4232_EECS: length 11.3
  BOTTOM w0.132: U79.1 25.34,127.55 24.8,127.01 R416.1 24.8,126.53 24.51,126.24 23.43,126.24 22.86,126.81 22.86,130.43 23.55,131.12 U73.63
FT4232_EEDATA: length 6.8
  BOTTOM w0.132: U73.61 24.55,130.97 23.96,130.39 R407.1 23.96,129.29 24.09,129.16 25.02,129.16 25.33,128.85 U79.3
FT4232_MCU_UART1_CTS_3V3: length 114
  TOP w0.132: U12.12 v1(113.98,151.45)
  L05_SIG2 w0.084: v1(28.05,142.19) 30.31,142.19 30.79,142.67 45.54,142.67 61.34,126.87 101.27,126.87 105.84,131.44 107.19,131.44 111.01,135.27 111.01,145.1 113.98,148.07 v1(113.98,151.45)
  BOTTOM w0.132: U73.28 28.55,142.69 v1(28.05,142.19)
FT4232_MCU_UART1_RTS_3V3: length 109.1
  TOP w0.132: v1(111.67,149.71) 112.12,150.16 112.76,150.16 112.81,150.11 U12.14
  L05_SIG2 w0.084: v1(29.05,143.46) 29.3,143.21 45.9,143.21 61.6,127.5 101.04,127.5 106.18,132.65 107.45,132.65 110.46,135.66 110.46,145.79 111.67,147 v1(111.67,149.71)
  BOTTOM w0.132: U73.29 v1(29.05,143.46)
FT4232_MCU_UART1_RX_3V3: length 113.8
  TOP w0.132: v1(112.59,150.63) 112.7,150.51 U12.13
  L05_SIG2 w0.084: v1(112.59,150.63) 113.12,150.09 113.12,148.02 110.71,145.61 110.71,135.47 107.58,132.34 106.31,132.34 101.14,127.18 61.47,127.18 45.72,142.93 30.61,142.93 30.33,142.65 27.5,142.65 v1(27.05,142.19)
  BOTTOM w0.132: U73.26 27.55,142.69 v1(27.05,142.19)
FT4232_MCU_UART1_TX_3V3: length 110.5
  TOP w0.132: U12.15 v1(112.59,149.71)
  L05_SIG2 w0.084: v1(28.05,143.46) 28.51,143.92 30.51,143.92 30.96,143.46 46.08,143.46 61.73,127.81 100.91,127.81 106.06,132.95 107.33,132.95 110.21,135.84 110.21,145.97 111.25,147.01 111.25,149.94 111.48,150.17 112.13,150.17 v1(112.59,149.71)
  BOTTOM w0.132: U73.27 v1(28.05,143.46)
FT4232_REF: length 1.6
  BOTTOM w0.254: R388.2 U73.6
FT4232_RESET: length 4.6
  BOTTOM w0.132: U73.14 C319.2 19.71,141.36 19.58,141.22 18.73,141.22 18.31,141.64 R381.1
FT4232_UART0_CTS_3V3: length 100.9
  TOP w0.132: U19.12 v1(109.89,130.75)
  L05_SIG2 w0.084: v1(23.55,145.88) 23.55,144.52 26.35,141.72 30.27,141.72 30.97,142.42 43.23,142.42 60.82,124.83 85.33,124.83 87.07,126.57 104.09,126.57 108.27,130.75 v1(109.89,130.75)
  BOTTOM w0.132: U73.18 v1(23.55,145.88)
FT4232_UART0_RTS_3V3: length 97.8
  TOP w0.132: U19.14 108.72,129.41 108.67,129.46 108.03,129.46 v1(107.58,129.01)
  L05_SIG2 w0.084: v1(107.58,129.01) 104.81,126.24 87.17,126.24 85.46,124.52 60.69,124.52 43.11,142.11 31.09,142.11 30.4,141.41 25.39,141.41 v1(23.55,143.26)
  BOTTOM w0.132: v1(23.55,143.26) 24.05,143.76 U73.19
FT4232_UART0_RX_3V3: length 98.6
  TOP w0.132: v1(108.49,129.92) 108.61,129.81 U19.13
  L05_SIG2 w0.084: v1(23.55,142.19) 24.79,140.95 43.83,140.95 60.56,124.22 85.58,124.22 87.3,125.93 105.15,125.93 108.04,128.82 108.04,129.47 v1(108.49,129.92)
  BOTTOM w0.132: U73.16 23.05,142.69 v1(23.55,142.19)
FT4232_UART0_TX_3V3: length 104.2
  TOP w0.132: U19.15 v1(108.49,129.01)
  L05_SIG2 w0.084: v1(23.55,146.85) 22.8,146.1 22.8,141.6 23.76,140.65 43.71,140.65 60.44,123.91 85.71,123.91 87.42,125.63 105.57,125.63 108.49,128.55 v1(108.49,129.01)
  BOTTOM w0.132: v1(23.55,146.85) 23.05,146.35 U73.17
FT4232_UART1_CTS_1V8: length 12.6
  TOP w0.132: U26.14 90.58,106.78 v1(89.93,107.43)
  BOTTOM w0.132: U85.9 83.13,107.05 84.77,105.41 89.73,105.41 90.42,106.11 90.42,106.94 v1(89.93,107.43)
FT4232_UART1_CTS_3V3: length 67.2
  L05_SIG2 w0.084: v1(28.55,134.42) 29.24,133.73 46.61,133.73 59.12,121.22 65.15,121.22 80.26,106.11 81.53,106.11 v1(81.93,106.52)
  BOTTOM w0.132: U85.12 v1(81.93,106.52) ; U73.53 v1(28.55,134.42)
FT4232_UART1_RTS_1V8: length 7.1
  TOP w0.132: U26.11 v1(88.63,106.39)
  BOTTOM w0.132: v1(88.63,106.39) 88.18,105.94 86.37,105.94 84.45,107.85 U85.7
FT4232_UART1_RTS_3V3: length 66.8
  L05_SIG2 w0.084: v1(28.55,135.33) 28.95,134.93 46.02,134.93 59.42,121.53 65.49,121.53 v1(79.57,107.45)
  BOTTOM w0.132: v1(28.55,135.33) 28.05,134.83 U73.54 ; v1(79.57,107.45) 79.92,107.81 80.78,107.81 80.83,107.85 U85.14
FT4232_UART1_RX_1V8: length 16.2
  TOP w0.132: U26.5 89.28,112.38 v1(88.63,113.03)
  BOTTOM w0.132: v1(88.63,113.03) 89.41,112.26 89.41,106.49 88.59,105.67 86.09,105.67 84.31,107.45 U85.8
FT4232_UART1_RX_3V3: length 60.8
  L05_SIG2 w0.084: v1(33.78,135.69) 46.61,135.69 60.46,121.83 66.08,121.83 v1(80.57,107.34)
  BOTTOM w0.132: U85.13 80.69,107.45 v1(80.57,107.34) ; v1(33.78,135.69) 33.28,135.19 U73.48
FT4232_UART1_TX_1V8: length 15
  TOP w0.132: U26.2 v1(91.23,111.99)
  BOTTOM w0.132: v1(91.23,111.99) 91.23,113.28 91.03,113.48 88.44,113.48 88.09,113.13 88.09,108.91 87.2,108.02 84.66,108.02 84.43,108.25 U85.6
FT4232_UART1_TX_3V3: length 66
  L05_SIG2 w0.084: v1(29.55,135.33) 30.36,136.15 46.48,136.15 60.49,122.14 66.72,122.14 v1(80.6,108.25)
  BOTTOM w0.132: v1(29.55,135.33) 29.05,134.83 U73.52 ; v1(80.6,108.25) U85.15
FT4232_USB_DM: length 18.6
  TOP w0.104: U15.5 13.69,140.48 13.43,140.48 v1(13.08,140.14) 12.69,140.53 12.12,140.53 11.91,140.32 J42.2
  L03_SIG1 w0.089: v1(23.55,137.93) 23.55,138.24 23.46,138.33 22.64,138.33 19.53,141.44 14.83,141.44 13.93,140.54 13.17,140.54 13.08,140.45 v1(13.08,140.14)
  BOTTOM w0.104: U73.7 22,138.19 22.14,138.33 23.15,138.33 v1(23.55,137.93)
FT4232_USB_DP: length 18.6
  TOP w0.104: J42.3 11.89,140.97 12.12,140.74 12.67,140.74 v1(13.08,141.15) 13.43,140.81 13.69,140.81 U15.4
  L03_SIG1 w0.089: v1(13.08,141.15) 13.08,140.84 13.17,140.75 13.84,140.75 14.74,141.66 19.62,141.66 22.73,138.54 23.46,138.54 23.55,138.63 v1(23.55,138.95)
  BOTTOM w0.104: v1(23.55,138.95) 23.15,138.55 22.13,138.55 21.99,138.69 U73.8
FT4232_USB_VBUS: length 8.6
  TOP w0.254: D7.1 13.24,138.65 12.22,139.67 J42.1 ; D7.1 13.78,137.98 v1(13.65,137.86) ; D7.1 U15.6
  BOTTOM w0.254: U76.4 10.27,136.13 10.67,136.53 11.57,136.53 ; 11.57,136.53 C329.2 ; 11.57,136.53 U76.6
FT4232_WKUP_UART0_CTS_3V3: length 93.4
  TOP w0.132: U21.12 112.5,121.48 v1(112.94,121.92)
  L05_SIG2 w0.084: v1(112.94,121.92) 112.94,123.72 111.34,125.32 87.55,125.32 85.84,123.61 60.36,123.61 44.78,139.19 v1(31.32,139.19)
  BOTTOM w0.132: U73.40 v1(31.32,139.19)
FT4232_WKUP_UART0_RTS_3V3: length 92.5
  TOP w0.132: v1(111.21,123.79) 111.65,123.34 111.65,122.7 111.61,122.65 U21.14
  L05_SIG2 w0.084: v1(111.21,123.79) 110.27,122.85 60.51,122.85 60.29,123.07 60.23,123.07 44.92,138.38 30.75,138.38 30.4,138.73 v1(30.4,139.19)
  BOTTOM w0.132: v1(30.4,139.19) 30.9,138.69 U73.41
FT4232_WKUP_UART0_RX_3V3: length 93.6
  TOP w0.132: U21.13 112.01,122.76 v1(112.12,122.87)
  L05_SIG2 w0.084: v1(31.32,140.19) 30.86,139.73 30.86,138.84 31.01,138.68 44.95,138.68 60.33,123.3 85.96,123.3 87.68,125.02 111.14,125.02 112.12,124.04 v1(112.12,122.87)
  BOTTOM w0.132: U73.38 v1(31.32,140.19)
FT4232_WKUP_UART0_TX_3V3: length 92.8
  TOP w0.132: U21.15 v1(111.21,122.87)
  L05_SIG2 w0.084: v1(111.21,122.87) 110.88,122.55 60.41,122.55 44.89,138.07 30.63,138.07 30,138.71 30,139.78 v1(30.4,140.19)
  BOTTOM w0.132: v1(30.4,140.19) 30.9,139.69 U73.39
GATE: length 40
  TOP w0.132: Q2.1 47.75,134.62 v1(47.37,134.24)
  L12_SIG4 w0.084: v1(47.37,134.24) 48.31,135.18 48.31,150.88 46.2,152.98 31.5,152.98 30.85,152.34 v1(30.76,152.34)
  BOTTOM w0.132: v1(30.76,152.34) C291.1 U66.10
GP1_TOUCH_EVT: length 96.6
  L05_SIG2 w0.084: v1(77.68,15.51) 78.32,16.15 83.14,16.15 83.19,16.11 84.56,16.11 95.71,27.25 156.09,27.25 161.94,33.11 161.94,34.84 v1(162.54,35.43)
  BOTTOM w0.132: J35.38 v1(162.54,35.43) ; U110.13 v1(77.68,15.51)
GPIO_CSI_RESETN: length 65.7
  L05_SIG2 w0.084: v1(81.27,13.93) 90.77,13.93 91.45,13.25 118.99,13.25 124.4,18.66 134.17,18.66 v1(139.25,23.74)
  BOTTOM w0.132: v1(139.25,23.74) R658.1 U108.1 ; U110.8 v1(81.27,13.93)
GPIO_EMMC_RSTN: length 118
  TOP w0.132: R303.1 U48.1 v1(152.62,52.83)
  L05_SIG2 w0.084: v1(152.62,52.83) 152.62,47.9 153.61,46.91 162.05,46.91 163.44,45.52 163.44,40.91 159,36.47 159,30.61 155.96,27.56 94.32,27.56 v1(84.27,17.51)
  BOTTOM w0.132: v1(84.27,17.51) 83.77,18.01 U110.1
GPIO_MCU_RGMII_RSTN: length 147.6
  L03_SIG1 w0.084: v1(37.98,129.35) 37.98,128.01 39.93,126.06 39.93,111.65 40.84,110.73 40.84,69.27 48.73,61.38 56.74,61.38 71.72,46.41 71.72,24.04 77.17,18.59 77.17,15.45 77.71,14.91 83.67,14.91 v1(84.27,15.51)
  BOTTOM w0.132: v1(84.27,15.51) 83.77,16.01 U110.5 ; v1(37.98,129.35) R409.2 R412.1 U82.1
GPIO_OSPI_RSTN: length 235.9
  L03_SIG1 w0.084: v1(158.38,137.23) 154.88,140.73 154.88,143.1 153.66,144.32 153.66,150.27 152.65,151.28 152.65,156.65 149.94,159.36 129.69,159.36 128.51,158.18 120.16,158.18 117.75,155.77 110.17,155.77 100,145.59 100,132.46 98.98,131.45 98.98,111.86 103.02,107.82 103.02,104.99 100.22,102.19 93.04,102.19 87.45,96.6 87.45,82.68 92.29,77.84 92.29,61.17 96.78,56.68 96.78,27.55 87.34,18.11 83.95,18.11 v1(83.36,17.51)
  BOTTOM w0.132: U74.1 v1(158.38,137.23) R390.1 ; U110.2 v1(83.36,17.51)
GPIO_PRG2_RGMII_RESETN: length 84.7
  L03_SIG1 w0.084: v1(71.77,86.73) 71.77,73.28 73.82,71.22 73.82,25.4 78.8,20.42 78.8,15.62 79.21,15.21 82.06,15.21 v1(83.36,16.51)
  BOTTOM w0.132: v1(71.77,86.73) R513.2 71.1,87.63 70.9,87.82 70.48,87.82 70.26,88.05 R506.1 U86.1 ; U110.4 v1(83.36,16.51)
GPIO_SGMII_PHY_INT: length 5.5
  TOP w0.132: R729.2 R58.1 145.34,141.64 145.34,144.16 145.74,144.56 J5.46
GPIO_SGMII_PHY_RST: length 222.6
  TOP w0.132: J5.6 153.74,149.61 v1(153.13,150.22) 153.01,150.34 R782.1
  L03_SIG1 w0.084: v1(153.13,150.22) 152.34,151.01 152.34,156.45 150.46,158.33 129.1,158.33 128.64,157.87 120.29,157.87 117.87,155.46 110.63,155.46 100.83,145.66 100.83,132.7 99.44,131.32 99.44,112.09 103.33,108.2 103.33,104.87 100.34,101.88 93.17,101.88 87.76,96.47 87.76,82.8 92.6,77.97 92.6,61.3 97.08,56.81 97.08,27.42 86.58,16.92 84.1,16.92 83.86,16.68 83.86,16.02 v1(83.36,15.51)
  BOTTOM w0.132: U110.6 v1(83.36,15.51)
GPIO_SPI0_RSTN: length 113.5
  TOP w0.132: v1(104.78,106.31) 104.92,106.17 R159.1 U28.1
  L03_SIG1 w0.084: v1(104.78,106.31) 104.78,103.89 101.85,100.97 93.99,100.97 91.25,98.23 91.25,92.71 92.9,91.06 92.9,61.42 97.39,56.94 97.39,27.28 86.62,16.51 v1(84.27,16.51)
  BOTTOM w0.132: U110.3 83.77,17.01 v1(84.27,16.51)
HB: length 3
  TOP w0.132: U14.18 68.75,140.11 68.63,139.99 C66.1
HDMI_GPMC_BRD_DET: length 105.7
  TOP w0.132: R235.1 86.35,65.81 86.42,65.74 87.22,65.74 87.45,65.52 U46.7 87.45,62.95 v1(88.1,62.3)
  L05_SIG2 w0.084: v1(88.1,62.3) 88.9,61.5 88.9,58.55 98.79,48.65 104.79,48.65 108.31,52.18 119.47,52.18 123,48.65 125.91,48.65 127.13,47.43 140.4,47.43 141.35,48.39 144.24,48.39 146.02,46.61 161.24,46.61 162.63,45.22 162.63,40.53 v1(157.54,35.43)
  BOTTOM w0.132: J35.18 v1(157.54,35.43)
HDR_MCU_UART1_CTS_1V8: length 6.2
  TOP w0.132: U8.1 118.81,156.15 118.49,156.46 118.49,156.98 117.49,157.98 115.31,157.98 115.18,157.85 U6.9
HDR_MCU_UART1_CTS_3V3: length 19.9
  TOP w0.132: J30.6 100.58,167.77 104.14,164.21 107.16,164.21 113.98,157.39 U6.12
HDR_MCU_UART1_RTS_3V3: length 28.8
  TOP w0.132: U6.14 112.81,156.63 112.76,156.67 112.12,156.67 v1(111.67,156.23)
  BOTTOM w0.132: v1(111.67,156.23) 99.65,168.25 91.97,168.25 J30.2
HDR_MCU_UART1_RX_1V8: length 5.6
  TOP w0.132: v1(116.58,157.14) 116.47,157.03 U6.8
  BOTTOM w0.132: v1(116.58,157.14) 117.43,157.14 118.24,156.34 118.24,155.19 118.78,154.65 U65.1
HDR_MCU_UART1_RX_3V3: length 25.5
  TOP w0.132: v1(112.59,157.14) 112.7,157.03 U6.13
  BOTTOM w0.132: J30.4 96.67,170.97 101,170.97 101.7,170.26 101.7,168.02 v1(112.59,157.14)
HDR_MCU_UART1_TX_3V3: length 21
  TOP w0.132: U6.15 v1(112.59,156.23)
  BOTTOM w0.132: J30.5 99.24,168.61 100.21,168.61 v1(112.59,156.23)
HDR_WKUP_UART0_CTS_3V3: length 16.4
  TOP w0.132: U23.1 114.05,114.36 114.3,114.62 114.3,126.68 J11.6
HDR_WKUP_UART0_RX_3V3: length 9.5
  BOTTOM w0.132: U83.1 113.58,115.86 113.77,116.05 113.77,118.82 114.58,119.63 114.58,121.88 J11.4
HS: length 43.8
  TOP w0.132: D8.1 89.03,126.24 87,124.21 70.61,124.21 67.69,127.13 C66.2 68.63,138.39 69.05,138.81 U14.20
IFORCE: length 16.7
  TOP w0.132: U34.B28 v1(158.36,86.59)
  BOTTOM w0.122: v1(158.36,86.59) 158.76,87 159.77,87
  BOTTOM w0.132: TP62.1 169.89,78.93 161.83,87 159.77,87
IN_SEL0: length 3.2
  TOP w0.132: U32.30 R193.1 R197.2
IN_SEL1: length 3.4
  TOP w0.132: U32.29 68.64,98.56 68.13,99.07 R189.1 R187.2
INA_ALERT: length 444.6
  TOP w0.132: R14.2 156.69,168.05 156.46,168.28 156.34,168.28 v1(156.02,168.59) ; R148.2 R147.1 110.72,109.03 110.23,108.54 106.92,108.54 v1(105.76,109.7) ; v1(179.71,160.07) 180.07,160.43 R18.2
  L03_SIG1 w0.084: v1(105.76,109.7) 107.92,109.7 111.25,113.03 111.25,117.09 111,117.35 111,120.29 108.01,123.27 108.01,129.15 107.7,129.47 107.7,132.38 110.25,134.93 110.25,146.7 114.68,151.13 117.68,151.13 118.75,152.19 130.11,152.19 131.08,153.16 138.46,153.16 v1(139.15,152.48) ; v1(169.37,149.46) 176.91,149.46 v1(179.66,152.21) 180.47,153.02 180.47,159.31 v1(179.71,160.07)
  L05_SIG2 w0.084: v1(179.66,152.21) 196.15,152.21 201.57,146.79 201.57,69.23 197.11,64.77 186.94,64.77 185.51,66.2 v1(183.13,66.2) ; v1(139.15,152.48) 144.48,152.48 145.16,153.16 146.69,153.16 147.17,152.68 152.01,152.68 v1(154.27,154.94)
  L10_SIG3 w0.084: v1(154.27,154.94) 156.21,154.94 160.85,150.3 168.52,150.3 v1(169.37,149.46)
  L12_SIG4 w0.084: v1(154.27,154.94) 154.27,166.85 v1(156.02,168.59) ; v1(105.76,109.7) 104.37,108.31 104.37,85.89 102.93,84.45 84.39,84.45 80.86,80.93 80.86,72.43 68.45,60.02 68.45,17.08 70.8,14.73 95.5,14.73 98.05,17.28 J21.4
  BOTTOM w0.132: R365.2 v1(169.37,149.46) ; R363.2 138.31,152.48 v1(139.15,152.48) ; R358.2 v1(154.27,154.94) ; R364.2 v1(179.66,152.21) ; R591.2 183.17,66.24 v1(183.13,66.2)
JTAG_CTI_RTCK: length 23.8
  TOP w0.132: v1(97.59,93.56) 97.6,93.56 97.6,93.63 97.83,93.85 99.53,93.85
  L03_SIG1 w0.084: v1(103.65,75.05) 103.65,75.96 100.66,78.95 100.66,90.49 v1(97.59,93.56)
  BOTTOM w0.132: R565.1 v1(103.65,75.05)
JTAG_CTI_TCK: length 24.7
  TOP w0.132: J13.11 v1(97.66,92.58) ; R227.1 R229.1 97.07,74.1 v1(97.16,74.02) 97.24,74.1 U41.2
  L03_SIG1 w0.084: v1(97.66,92.58) 98.12,92.13 98.12,74.98 v1(97.16,74.02)
  BOTTOM w0.132: U41.2 97.24,74.1 v1(97.16,74.02)
JTAG_DIR: length 3.1
  TOP w0.132: 113.54,63.56 113.66,63.68 113.66,63.93 113.53,64.06 U43.3 ; 113.54,63.56 U43.2 ; 113.54,63.56 114.11,62.99 R254.2
JTAG_EMU0: length 17
  TOP w0.132: v1(92.27,85.35) 91.95,85.35 91.82,85.22 U37.8 ; J13.13 v1(97.66,91.31)
  L12_SIG4 w0.084: v1(97.66,91.31) 97.66,88.87 94.14,85.35 v1(92.27,85.35)
  BOTTOM w0.132: v1(92.27,85.35) 91.82,85.79 U87.8 92.68,87.54 92.9,87.76 R504.2
JTAG_EMU1: length 21.2
  TOP w0.132: v1(92.27,86.69) 91.95,86.69 91.82,86.82 U37.1 ; J13.14 v1(103.07,91.31)
  L12_SIG4 w0.084: v1(103.07,91.31) 102.57,91.82 96.58,91.82 95.39,90.63 95.39,89.81 v1(92.27,86.69)
  BOTTOM w0.132: R521.2 93.03,83.99 92.58,84.44 ; 92.58,84.44 92.85,84.71 92.85,86.11 v1(92.27,86.69) ; 92.58,84.44 U87.1
JTAG_EMU_RSTN: length 58.7
  TOP w0.132: J13.15 R213.2 96.94,90.57 96.71,90.8 v1(96.71,91.25) ; U50.6 v1(108.34,52.87)
  L03_SIG1 w0.084: v1(108.34,52.87) 108.34,55.17 95.95,67.56 95.95,90.49 v1(96.71,91.25) 94.04,93.92 94.04,98.8 v1(94.55,99.3)
  BOTTOM w0.132: R472.1 94.72,99.47 94.55,99.3 v1(94.55,99.3)
JTAG_MIPI_EMU0_1V8: length 21
  TOP w0.132: U37.5 90.32,84.17 89.98,83.83 88.27,83.83 v1(88.27,83.83) R217.2
  BOTTOM w0.132: J32.38 98.14,91.47 97.85,91.76 90.74,91.76 88.06,89.08 88.06,85.04 88.27,84.84 v1(88.27,83.83)
JTAG_MIPI_EMU1_1V8: length 14.8
  TOP w0.132: v1(88.46,88.46) 88.73,88.73 R214.2 89.28,88.14 89.88,87.54 U37.4
  BOTTOM w0.132: J32.40 97.95,90.97 97.16,90.17 90.17,90.17 v1(88.46,88.46)
JTAG_MIPI_RTCK: length 31.1
  TOP w0.132: R223.1 v1(104.01,77.14)
  L03_SIG1 w0.084: v1(107.12,99.31) 106.67,99.31 106.35,99.63 103.12,99.63 102.62,99.12 102.62,96.46 104.58,94.49 104.58,77.71 v1(104.01,77.14)
  BOTTOM w0.132: J32.7 106.78,98.97 v1(107.12,99.31)
JTAG_MIPI_TCK: length 32.5
  TOP w0.132: v1(103.12,101.66) 103.6,101.19 103.6,100.03 103.27,99.7 101.8,98.23 101.8,87.25 96.37,81.82 R221.1 R222.1 97.1,78.17 v1(97.17,78.09) U39.2
  BOTTOM w0.132: v1(103.12,101.66) 103.12,100.79 103.94,99.97 J32.3 ; U39.2 v1(97.17,78.09)
JTAG_MUX_SEL: length 69.6
  TOP w0.132: v1(110.43,74.66) 109.51,74.66 109.27,74.9 U42.1
  BOTTOM w0.132: J43.2 121.41,27.05 108.33,27.05 105.65,29.73 105.65,66.78 110.43,71.56 v1(110.43,74.66)
JTAG_TCK: length 23.2
  TOP w0.132: U43.12 108.2,65.06 107.76,65.51 107.49,65.51 106.93,66.06 106.93,67.16 108.61,68.83 110.55,68.83 111.32,69.6 111.32,76.9 110.05,78.17 107.7,78.17 107.32,77.8 U42.4
JTAG_TDI: length 43.7
  TOP w0.132: v1(107.57,65.06) 108.07,64.56 U43.13 ; v1(96.81,98.39) R196.2 97.32,97.35 97.64,97.66 J13.3
  L03_SIG1 w0.084: v1(96.81,98.39) 96.81,95.97 100.96,91.82 100.96,79.07 104.1,75.93 104.1,68.53 v1(107.57,65.06)
JTAG_TDIS: length 2.7
  TOP w0.132: J13.4 106.64,97.66 107.33,96.97 R195.2
JTAG_TDO: length 76.9
  TOP w0.132: v1(96.52,94.31) R202.1 97.7,95 97.83,95.12 J13.7
  L12_SIG4 w0.084: v1(57.15,43.75) 64.06,50.66 64.06,56.92 79.91,72.77 79.91,81.33 84.31,85.72 90.11,85.72 90.93,86.55 90.93,87.12 91.38,87.57 92.65,87.57 95.08,90 95.08,92.88 v1(96.52,94.31)
  BOTTOM w0.132: v1(57.15,43.75) 56.59,44.31 U101.7
JTAG_TMS: length 50
  TOP w0.132: J13.1 95.77,98.93 v1(94.49,100.21) ; v1(107.48,66.08) 107.79,66.08 108.3,65.56 U43.11
  L03_SIG1 w0.084: v1(107.48,66.08) 105.18,68.38 105.18,75.29 101.98,78.49 101.98,81.92 101.83,82.07 101.83,96.1 98.87,99.06 95.64,99.06 v1(94.49,100.21)
  BOTTOM w0.132: R470.1 94.82,100.55 v1(94.49,100.21)
JTAG_TRST#: length 47.2
  TOP w0.132: J13.2 v1(103.07,98.93) ; U43.10 v1(108.49,66.06)
  L03_SIG1 w0.084: v1(108.49,66.06) 107.44,67.1 107.44,93.19 103.07,97.56 v1(103.07,98.93)
  L10_SIG3 w0.084: v1(94.6,98.39) 95.15,98.93 v1(103.07,98.93)
  BOTTOM w0.132: R475.1 v1(94.6,98.39)
LCD_BRD_DET: length 166.7
  TOP w0.132: v1(89.4,62.3) 88.75,62.95 U46.5 88.75,65.89 R237.1
  L05_SIG2 w0.084: v1(155.35,28.04) 154.48,28.91 127,28.91 121.16,34.75 121.16,48.39 118.62,50.93 113.54,50.93 112.86,51.6 108.17,51.6 104.91,48.35 98.67,48.35 90.95,56.07 90.93,56.07 87.69,59.31 87.69,62.46 87.93,62.71 89,62.71 v1(89.4,62.3)
  L10_SIG3 w0.084: v1(200.51,10.7) 201.5,11.69 201.5,28.05 200.93,28.62 189.48,28.62 188.17,27.3 156.08,27.3 v1(155.35,28.04)
  BOTTOM w0.132: J38.40 v1(200.51,10.7)
LCD_BRD_TOUCH_INT: length 209.5
  TOP w0.132: R36.1 U7.7 139.81,154.14 140.32,153.63 v1(140.32,151.2)
  L05_SIG2 w0.084: v1(199.58,15.7) 200.02,16.14 201.05,16.14 201.93,17.02 201.93,34.9 200.89,35.94 200.89,66.15 202.08,67.34 202.08,148.08 196.7,153.47 178.32,153.47 175.71,150.86 150.39,150.86 149.48,151.76 148.08,151.76 147.47,151.15 143.61,151.15 142.83,150.36 141.15,150.36 v1(140.32,151.2)
  BOTTOM w0.132: J38.29 200.08,16.2 v1(199.58,15.7)
LCD_BRD_TOUCH_RESETN: length 4.7
  BOTTOM w0.132: U113.1 R686.1 79.51,13.25 79.77,13.51 U110.11
LCD_DISPLAY_EN: length 132.1
  L10_SIG3 w0.084: v1(79.38,11.75) 80.55,10.57 107.62,10.57 111.85,6.34 138.5,6.34 141.16,9 180.02,9 186.2,15.18 199.99,15.18 v1(200.51,15.7)
  BOTTOM w0.132: v1(79.38,11.75) 79.38,12.62 80,13.25 R687.2 80.53,13.76 80.27,14.02 U110.10 ; J38.30 v1(200.51,15.7)
LCD_SHIELD: length 40.5
  TOP w0.381: v1(201.3,33.35) 205.83,28.82 v1(205.83,7.6)
  BOTTOM w0.381: J38.SH1 201.43,32.12 FL15.2 v1(201.3,33.35) 202.8,33.35 202.86,33.3 J38.SH3 ; v1(205.83,7.6) J38.SH4 202.31,7.6 201.43,8.48 J38.SH2
LCD_TOUCH_RESETN: length 134.1
  L10_SIG3 w0.084: v1(199.58,10.7) 198.84,9.96 181.41,9.96 180.15,8.7 141.29,8.7 136.84,4.25 110.62,4.25 107.77,7.11 94.81,7.11 93.19,8.72 v1(74.39,8.72)
  BOTTOM w0.132: v1(74.39,8.72) R698.1 U113.4 ; J38.39 200.08,11.2 v1(199.58,10.7)
LED1: length 4.1
  TOP w0.132: LD11.1 60.12,115.71 60.93,114.9 61.19,114.9 v1(61.51,114.59)
  BOTTOM w0.132: U84.3 v1(61.51,114.59)
LED2: length 3
  TOP w0.132: v1(62.78,114.59) 62.25,114.59 61.85,114.99 LD12.1
  BOTTOM w0.132: U84.4 v1(62.78,114.59)
LED3: length 2.9
  TOP w0.132: v1(64.05,114.59) 64.55,114.59 64.77,114.81 LD13.1
  BOTTOM w0.132: U84.5 v1(64.05,114.59)
LED4: length 3.8
  TOP w0.132: v1(65.32,114.59) 66.44,115.71 LD14.1
  BOTTOM w0.132: U84.6 v1(65.32,114.59)
LED5: length 12.6
  TOP w0.132: v1(65.32,111.6) 64.01,112.9 57.98,112.9 56.39,114.49 LD10.1
  BOTTOM w0.132: U84.11 v1(65.32,111.6)
LED6: length 13.8
  TOP w0.132: LD15.1 53.57,114.97 55.96,112.59 63.06,112.59 v1(64.05,111.6)
  BOTTOM w0.132: U84.12 v1(64.05,111.6)
LED7: length 15.6
  TOP w0.132: LD9.1 50.8,114.43 52.91,112.32 62.05,112.32 v1(62.78,111.6)
  BOTTOM w0.132: U84.13 v1(62.78,111.6)
LED8: length 17.6
  TOP w0.132: LD8.1 48.01,113.6 49.56,112.05 61.06,112.05 v1(61.51,111.6)
  BOTTOM w0.132: U84.14 v1(61.51,111.6)
LM5140_COMP1: length 6.8
  BOTTOM w0.132: C308.1 106.45,144.95 R375.2 105.19,144.95 105.01,144.76 105.01,143.53 105.47,143.07 105.47,141.23 104.95,140.71 U75.29
LM5140_COMP2: length 4
  BOTTOM w0.132: C350.1 105.32,131.13 R399.2 105.07,133.32 104.95,133.43 U75.2
MAIN_UART1_SEL: length 124.3
  TOP w0.132: U26.1 91.88,112.15 R134.2 92.5,112.3 v1(92.72,112.08)
  L03_SIG1 w0.084: v1(92.72,112.08) 92.21,112.59 74.54,112.59 68.7,106.75 68.7,96.02 70.36,94.36 70.36,73.83 73.52,70.67 73.52,24.84 78.19,20.17 78.19,17.03 v1(77.68,16.51)
  BOTTOM w0.132: U110.15 v1(77.68,16.51)
MCASP1_ACLKR: length 63.6
  TOP w0.132: v1(139.64,73.27) 141.03,74.66 156.85,74.66 159.17,72.33 173.46,72.33 174.95,70.85 188.86,56.93 188.86,53.75 188.53,53.42 187.87,53.42 v1(187.41,52.96)
  BOTTOM w0.132: v1(187.41,52.96) U100.7 ; R577.2 v1(139.64,73.27)
MCASP1_ACLKR_3V3: length 6.1
  BOTTOM w0.132: J35.115 187.04,44.23 187.41,44.6 U100.14
MCASP1_ACLKX: length 58.8
  TOP w0.132: v1(141.67,73.27) 143.42,71.51 151.87,71.51 154.93,68.45 166.85,68.45 169.15,70.75 172.8,70.75 185.02,58.53 185.02,54.26 v1(185.41,53.87)
  BOTTOM w0.132: v1(185.41,53.87) 185.91,53.37 U100.4 ; R575.2 v1(141.67,73.27)
MCASP1_ACLKX_3V3: length 6.1
  BOTTOM w0.132: J35.109 185.54,44.25 185.91,44.63 U100.17
MCASP1_AFSR: length 58.2
  TOP w0.132: v1(143.7,73.27) 144.83,74.39 155.88,74.39 155.88,74.39 156.74,74.39 159.06,72.07 173.35,72.07 188.47,56.95 v1(188.47,53.91)
  BOTTOM w0.132: U100.8 187.91,53.36 v1(188.47,53.91) ; R573.2 v1(143.7,73.27)
MCASP1_AFSR_3V3: length 6.1
  BOTTOM w0.132: J35.117 187.54,44.28 187.91,44.66 U100.13
MCASP1_AFSX: length 65.3
  TOP w0.132: v1(183.58,51.12) 184.76,52.3 184.76,58.42 172.69,70.48 169.27,70.48 166.09,67.31 155.7,67.31 151.77,71.25 139.62,71.25 v1(137.6,73.27)
  BOTTOM w0.132: U100.1 v1(183.58,51.12) ; R579.2 v1(137.6,73.27)
MCASP1_AFSX_3V3: length 8.1
  BOTTOM w0.132: J35.105 184.54,44.82 183.43,45.93 183.43,49.29 183.76,49.62 U100.20
MCASP1_AHCLKR: length 56.3
  TOP w0.132: v1(188.41,52.96) 187.97,52.51 187.23,52.51 186.86,52.88 186.86,57.81 173.13,71.54 168.7,71.54 167.28,70.13 158.93,70.13 157.99,71.07 157.99,72.36 156.49,73.86 148.36,73.86 v1(147.76,73.27)
  BOTTOM w0.132: R569.2 v1(147.76,73.27) ; U100.9 v1(188.41,52.96)
MCASP1_AHCLKR_3V3: length 6.1
  BOTTOM w0.132: U100.12 188.41,44.71 188.04,44.34 J35.119
MCASP1_AHCLKX: length 48.8
  TOP w0.132: v1(186.41,52.96) 186.41,57.88 173.02,71.28 168.81,71.28 166.65,69.11 159.05,69.11 156.08,72.09 156.08,73.28 155.77,73.6 153.68,73.6 v1(153.23,73.14)
  BOTTOM w0.132: R590.2 v1(153.23,73.14) ; v1(186.41,52.96) U100.5
MCASP1_AHCLKX_3V3: length 6.1
  BOTTOM w0.132: J35.111 186.04,44.31 186.41,44.68 U100.16
MCASP1_AXR0: length 56.1
  TOP w0.132: v1(145.67,73.27) 146.53,74.12 156.63,74.12 159.72,71.04 162.66,71.04 162.79,70.92 167.7,70.92 168.59,71.81 173.24,71.81 187.39,57.66 v1(187.39,53.91)
  BOTTOM w0.132: v1(145.67,73.27) 145.67,73.34 145.73,73.41 R571.2 ; U100.6 186.91,53.44 v1(187.39,53.91)
MCASP1_AXR0_3V3: length 6.1
  BOTTOM w0.132: J35.113 186.54,44.3 186.91,44.67 U100.15
MCASP1_AXR1: length 46
  TOP w0.132: v1(185.41,52.96) 186.06,53.6 186.06,57.87 172.91,71.01 168.96,71.01 166.7,68.76 158.95,68.76 155.46,72.25 v1(155.46,73.14)
  BOTTOM w0.132: v1(185.41,52.96) U100.3 ; R588.2 v1(155.46,73.14)
MCASP1_AXR1_3V3: length 6.1
  BOTTOM w0.132: J35.107 185.04,44.26 185.41,44.64 U100.18
MCU_ADC0_CH0: length 31
  TOP w0.132: U34.K5 v1(151.96,105.79)
  L12_SIG4 w0.084: v1(151.96,105.79) 151.55,106.2 150.99,106.2 150.76,106.43 150.76,109.36 153.67,112.27 153.67,114.6 154.69,115.62 154.69,121.57 155.25,122.13 155.25,127.76 156.02,128.54 156.02,131.72 J10.4
MCU_ADC0_CH1: length 26.7
  TOP w0.132: U34.J3 v1(152.76,107.39)
  L12_SIG4 w0.084: v1(152.76,107.39) 152.36,107.78 151.81,107.78 151.56,108.03 151.56,109.4 154.75,112.59 154.75,115.25 154.99,115.49 154.99,116.69 157.48,119.18 J10.5
MCU_ADC0_CH2: length 30.6
  TOP w0.132: U34.J1 v1(152.76,108.99)
  L05_SIG2 w0.084: v1(152.76,108.99) 152.76,111.16 153.72,112.13 153.72,113.99 155.77,116.04 155.77,125.54 158.15,127.93 164.38,127.93 165.1,128.65 J10.11
MCU_ADC0_CH3: length 37.3
  TOP w0.132: U34.J5 v1(152.76,105.79)
  L12_SIG4 w0.084: v1(152.76,105.79) 153.16,105.38 153.16,104.83 152.93,104.6 149.36,104.6 149.16,104.8 149.16,109.22 153.04,113.09 153.04,116.21 152.76,116.48 152.76,120.5 154.64,122.38 154.64,127.51 153.61,128.54 153.61,131.59 J10.2
MCU_ADC0_CH4: length 42
  TOP w0.132: U34.K4 v1(151.96,106.59)
  L05_SIG2 w0.084: v1(151.96,106.59) 151.55,106.18 151.55,105.63 151.32,105.4 150.19,105.4 149.95,105.65 149.95,105.95 149.72,106.18 148.61,106.18 148.14,106.65 148.14,107.13 148.14,107.14 148.14,109.6 148.14,109.6 148.28,109.73 148.28,113.52 147.83,113.97 147.83,119.6 148.58,120.36 152.14,120.36 153.02,121.24 153.02,127.69 154.18,128.84 161.14,128.84 J10.9
MCU_ADC0_CH5: length 31.9
  TOP w0.132: U34.J4 v1(152.76,106.59)
  L12_SIG4 w0.084: v1(152.76,106.59) 153.16,107 153.16,109.67 156.22,112.72 156.22,117.06 168.35,129.18 169.1,129.18 J10.15
MCU_ADC0_CH6: length 28.5
  TOP w0.132: U34.J2 v1(152.76,108.19)
  L12_SIG4 w0.084: J10.6 158.69,131.59 158.69,119.95 155.3,116.56 155.3,115.37 155.13,115.2 155.13,112.08 152.36,109.31 152.36,108.58 v1(152.76,108.19)
MCU_ADC0_CH7: length 30.3
  TOP w0.132: U34.J6 v1(152.76,104.99)
  L12_SIG4 w0.084: J10.3 154.94,122.25 153.67,120.98 153.67,115.04 153.37,114.73 153.37,112.73 149.96,109.32 149.96,105.63 150.19,105.4 152.35,105.4 v1(152.76,104.99)
MCU_ADC0_REFN: length 39.2
  TOP w0.132: C74.1 164.21,134.92 164.08,134.8 164.08,133.82 J10.12 ; U34.K2 v1(151.96,108.19)
  L05_SIG2 w0.084: v1(151.96,108.19) 152.36,108.6 152.36,111.2 153.42,112.25 153.42,114.12 154.62,115.33 154.62,128.08 154.77,128.23 163.47,128.23 164.02,128.78 164.02,131.72 J10.12
MCU_ADC0_REFP: length 40.3
  TOP w0.132: U34.K3 v1(151.96,107.39) ; J10.10 163.7,133.94 163.7,134.69 163.47,134.92 C73.1
  L05_SIG2 w0.084: v1(151.96,107.39) 151.55,107.8 151.55,110.82 153.11,112.38 153.11,114.25 153.61,114.74 153.61,127.76 154.38,128.54 163.08,128.54 163.64,129.1 163.64,131.72 J10.10
MCU_ADC1_AIN1: length 25.3
  TOP w0.132: U34.G6 v1(154.36,104.99)
  BOTTOM w0.122: v1(154.36,104.99) 154.75,104.6 157.72,104.6 157.95,104.83 157.95,109.56 157.95,109.56 157.95,109.63
  BOTTOM w0.132: 157.95,109.63 157.95,110.87 162.65,115.57 162.65,118.2 165.35,120.9 TP34.1
