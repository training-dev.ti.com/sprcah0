# Allegro board PROC062E4_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PRG2_RGMII2_RXC_R: length 1.7
  BOTTOM w0.132: R517.2 56.6,84.21 56.59,84.2 56.46,84.2 56.29,84.02 U88.32
PRG2_RGMII2_TD0: length 72.8
  TOP w0.132: RA1.9 v1(110.61,100.16)
  L10_SIG3 w0.084: v1(110.61,100.16) 110.07,99.62 109.57,99.62 108.51,98.56 108.51,94.84 101.76,88.1 95.05,88.1 94.9,88.25 94.9,88.73 94.74,88.88 94.39,88.88 94.24,88.73 94.24,88.25 94.08,88.1 93.73,88.1 93.58,88.25 93.58,89.21 93.42,89.36 93.07,89.36 92.92,89.21 92.92,88.25 92.76,88.1 91.35,88.1 89.71,89.74 59.75,89.74 v1(58.53,88.51)
  BOTTOM w0.132: U88.28 55.4,86.11 55.8,86.11 56,86.3 56.18,86.3 57.2,87.31 57.2,87.78 57.92,88.51 v1(58.53,88.51)
PRG2_RGMII2_TD1: length 72.1
  TOP w0.132: RA1.10 110.26,99.6 v1(109.69,100.16)
  L10_SIG3 w0.084: v1(57.21,88.46) 58.95,90.2 95.35,90.2 95.51,90.04 95.51,89.34 95.66,89.18 96.01,89.18 96.17,89.34 96.17,90.04 96.32,90.2 96.67,90.2 96.83,90.04 96.83,89.34 96.98,89.18 97.33,89.18 97.49,89.34 97.49,90.04 97.64,90.2 98,90.2 98.15,90.04 98.15,89.34 98.3,89.18 98.66,89.18 98.81,89.34 98.81,90.04 98.96,90.2 101.09,90.2 104.9,94.01 104.9,95.83 109.24,100.16 v1(109.69,100.16)
  BOTTOM w0.132: U88.27 55.85,86.52 56.69,87.37 56.69,87.94 v1(57.21,88.46)
PRG2_RGMII2_TD2: length 74.3
  TOP w0.132: RA1.11 v1(110.61,99.1)
  L10_SIG3 w0.084: v1(110.61,99.1) 110.15,98.64 109.59,98.64 108.97,98.02 108.97,94.82 101.79,87.64 72.11,87.64 71.45,88.3 65.66,88.3 65.5,88.15 65.5,87.49 65.35,87.33 65,87.33 64.84,87.49 64.84,88.15 64.69,88.3 64.34,88.3 64.18,88.15 64.18,87.49 64.03,87.33 63.68,87.33 63.52,87.49 63.52,88.15 63.37,88.3 63.02,88.3 62.86,88.15 62.86,87.49 62.71,87.33 62.36,87.33 62.2,87.49 62.2,88.15 62.05,88.3 61.71,88.3 60.33,86.93 56.89,86.93 56.29,87.53 v1(56.29,88.46)
  BOTTOM w0.132: v1(56.29,88.46) 56.29,87.53 55.78,87.02 U88.26
PRG2_RGMII2_TD3: length 75.6
  TOP w0.132: v1(115.75,103.38) 116.38,104.01 116.9,104.01 118.03,102.88 R180.2
  L10_SIG3 w0.084: v1(115.75,103.38) 110.27,103.38 108.15,101.26 100.2,101.26 100.05,101.1 100.05,99.97 99.9,99.82 99.54,99.82 99.39,99.97 99.39,101.1 99.24,101.26 98.88,101.26 98.73,101.1 98.73,99.97 98.58,99.82 98.22,99.82 98.07,99.97 98.07,101.1 97.92,101.26 91.2,101.26 80.59,90.65 57.51,90.65 v1(55.32,88.46)
  BOTTOM w0.132: v1(55.32,88.46) U88.25
PRG2_RGMII2_TX_CTL: length 75.5
  TOP w0.132: RA5.15 v1(110.61,87.51)
  L10_SIG3 w0.084: v1(110.61,87.51) 110.61,87.13 104.12,80.64 78.18,80.64 78.03,80.8 78.03,81.11 77.88,81.27 77.52,81.27 77.37,81.11 77.37,80.8 77.22,80.64 76.86,80.64 76.71,80.8 76.71,81.11 76.56,81.27 76.2,81.27 76.05,81.11 76.05,80.8 75.9,80.64 75.54,80.64 75.39,80.8 75.39,81.11 75.23,81.27 74.88,81.27 74.73,81.11 74.73,80.8 74.57,80.64 74.22,80.64 74.07,80.8 74.07,81.11 73.91,81.27 73.56,81.27 73.41,81.11 73.41,80.8 73.25,80.64 72.9,80.64 72.75,80.8 72.75,81.11 72.59,81.27 72.24,81.27 72.09,81.11 72.09,80.8 71.93,80.64 71.58,80.64 71.42,80.8 71.42,81.11 71.27,81.27 70.92,81.27 70.76,81.11 70.76,80.8 70.61,80.64 70.26,80.64 70.1,80.8 70.1,81.11 69.95,81.27 69.6,81.27 69.44,81.11 69.44,80.8 69.29,80.64 68.94,80.64 68.78,80.8 68.78,81.11 68.63,81.27 68.28,81.27 68.12,81.11 68.12,80.8 67.97,80.64 67.61,80.64 67.46,80.8 67.46,81.11 67.31,81.27 66.95,81.27 66.8,81.11 66.8,80.8 66.65,80.64 66.29,80.64 66.14,80.8 66.14,81.11 65.99,81.27 65.63,81.27 65.48,81.11 65.48,80.8 65.33,80.64 64.15,80.64 61.63,78.13 57.19,78.13 55.8,79.51 v1(55.8,80.72)
  BOTTOM w0.132: v1(55.8,80.72) 55.25,81.27 U88.37
PRG2_RGMII2_TXC: length 76.2
  TOP w0.132: v1(116.71,102.87) 117.03,102.55 117.03,102.17 117.35,101.85 R183.2
  L10_SIG3 w0.084: v1(116.71,102.87) 116.4,103.19 116.4,103.44 115.92,103.92 110.05,103.92 108.32,102.19 91.26,102.19 80.34,91.26 57.12,91.26 54.71,88.84 54.71,87.25 56.19,85.77 v1(56.57,85.77)
  BOTTOM w0.132: v1(56.57,85.77) 56.22,85.77 56.04,85.6 55.97,85.6 55.9,85.52 U88.29
PRG2_RGMII_INTN: length 267
  TOP w0.132: U31.44 51.07,106.22 50.42,106.86 R151.1 50.15,107.33 v1(49.66,107.82)
  L03_SIG1 w0.084: v1(49.74,79.34) 48.2,80.89 48.2,106.36 v1(49.66,107.82)
  L05_SIG2 w0.084: v1(39.09,91.55) 39.09,84.73 42.01,81.81 56.33,81.81 57.52,80.63 61.59,80.63 62.27,81.3 86.19,81.3 91.79,75.69 110.64,75.69 122.07,64.26 122.07,57.53 126.27,53.33 128.18,53.33 132.04,57.19 132.04,66.16 135.07,69.19 156.06,69.19 157.86,70.99 162.57,70.99 167.33,66.23 167.33,63.3 170.79,59.84 170.79,50.42 172.47,48.74 178.94,48.74 181.61,51.42 181.61,54.48 185.06,57.94 188.97,57.94 v1(189.34,57.57)
  L12_SIG4 w0.084: v1(49.74,79.34) 49.33,78.93 42.23,78.93 39.09,82.07 v1(39.09,91.55)
  BOTTOM w0.132: U88.44 51.07,80.79 50.42,80.14 R542.1 50.08,79.68 49.75,79.34 v1(49.74,79.34) ; U45.5 v1(189.34,57.57)
PRG2_RGMII_INTN_3V3: length 58.3
  TOP w0.132: v1(181.61,72.77) 181.05,73.33 174.57,73.33 165.69,82.21 165.69,88.94 164.06,90.58 162.62,90.58 161.41,91.79 U34.A22
  L03_SIG1 w0.084: v1(181.61,72.77) 182.6,72.77 184.01,71.36 184.01,67.55 185.83,65.72 185.83,58.52 v1(189.48,54.86)
  BOTTOM w0.132: U45.8 R270.1 v1(189.48,54.86)
PRG2_RGMII_RESETN: length 64.7
  TOP w0.132: 51.57,105.73 51.57,106.22 50.99,106.8 50.99,108.52 v1(51.37,108.9)
  L03_SIG1 w0.084: v1(51.37,78.11) 51.05,78.43 51.05,78.75 48.5,81.29 48.5,105.02 51.37,107.89 v1(51.37,108.9)
  L12_SIG4 w0.084: v1(51.37,78.11) 52.01,77.47 61.02,77.47 66.43,82.87 v1(66.43,87.63)
  BOTTOM w0.132: v1(51.37,78.11) 50.94,78.53 50.94,80.16 51.57,80.78 51.57,81.27 ; v1(66.43,87.63) U86.4 R514.1
PRG_EARTH: length 3.2
  BOTTOM w0.254: R473.1 13.1,102.69 v1(13.35,102.93) ; v1(11.37,101.91) C489.1 v1(10.09,100.99)
PRI_INN: length 6.2
  TOP w0.132: R173.2 C145.1 R172.1 76.05,103.07 75.22,102.25 75.22,99.71 75.07,99.56 U32.14
R_PRG2_PRU1_GP6: length 10.3
  TOP w0.132: RA2.6 v1(132.71,93.98) ; U34.AC17 v1(140.76,95.39)
  BOTTOM w0.122: 136.18,94.97 136.19,94.98 140.35,94.98 v1(140.76,95.39)
  BOTTOM w0.132: 136.18,94.97 134.73,93.52 133.17,93.52 v1(132.71,93.98)
R_PRG2_PRU1_GP8: length 11.6
  TOP w0.132: v1(133.67,93.98) 133.67,93.98 133.03,93.35 RA2.5 ; U34.AD15 v1(139.96,96.99)
  L10_SIG3 w0.084: v1(133.67,93.98) 135.13,93.98 136.14,95 140.12,95 140.35,95.23 140.35,96.6 v1(139.96,96.99)
R_PRG2_PRU1_GP11: length 10.4
  TOP w0.132: RA2.8 v1(132.71,95.12) ; U34.AD14 v1(139.96,98.59)
  L10_SIG3 w0.084: v1(132.71,95.12) 135.79,98.2 138.52,98.2 138.76,98.45 138.76,98.75 138.99,98.98 139.56,98.98 v1(139.96,98.59)
R_PRG2_PRU1_GP16: length 9.8
  TOP w0.132: U34.AE14 v1(139.16,98.59) ; RA2.7 133.03,94.48 133.67,95.12 v1(133.67,95.12)
  L10_SIG3 w0.084: v1(133.67,95.12) 133.99,95.44 133.99,95.67 135.72,97.4 138.36,97.4 139.16,98.2 v1(139.16,98.59)
R_SOC_SPI1_CS1: length 3.1
  TOP w0.132: v1(163.54,35.43) R311.2
  BOTTOM w0.132: R311.2 v1(163.54,35.43)
RAMP: length 2.1
  TOP w0.132: C62.1 77.77,141.41 U14.5
REFCLK0N: length 5.5
  TOP w0.107: J5.58 136.14,144.77 135.89,144.53 135.89,142.67 136.29,142.28 R60.1 135.99,142.28 135.86,142.15 135.86,141.5 R725.1
REFCLK0N_R: length 52
  TOP w0.107: U34.AF9 v1(138.36,102.59) ; v1(136.14,139.53) 135.83,139.84 135.83,140.15 135.98,140.3 R725.2
  L12_SIG4 w0.076: v1(136.14,139.53) 135.88,139.53 135.75,139.41 135.75,136.23 126.95,127.43 126.95,106.42 129.9,103.48 134.79,103.48 135.88,102.39 138.15,102.39 v1(138.36,102.59)
REFCLK0P: length 5.4
  TOP w0.107: R724.1 135.57,141.5 135.57,142.15 135.44,142.28 R59.1 135.19,142.28 135.6,142.68 135.6,144.52 135.34,144.77 J5.59
REFCLK0P_R: length 52.1
  TOP w0.107: U34.AF10 v1(138.36,101.79) ; R724.2 135.54,139.97 135.54,139.78 v1(135.29,139.53)
  L12_SIG4 w0.076: v1(135.29,139.53) 135.47,139.35 135.47,136.35 126.67,127.55 126.67,106.31 129.78,103.2 134.67,103.2 135.76,102.11 138.03,102.11 v1(138.36,101.79)
REFCLK1N: length 3.2
  TOP w0.107: R727.1 136.68,150.48 136.68,150.21 R40.1 136.69,149.7 136.69,148.91 136.94,148.66 J5.27
REFCLK1N_R: length 63.4
  TOP w0.107: v1(136.94,152.61) 136.65,152.61 136.55,152.5 136.55,152.16 R727.2 ; U34.AE8 v1(139.16,103.39)
  L12_SIG4 w0.076: v1(139.16,103.39) 138.77,103.77 138.14,103.77 137.82,103.45 136.17,103.45 135.32,104.3 132.08,104.3 130.25,106.13 130.25,110.5 128.99,111.76 128.99,127.74 137.24,135.99 137.24,140.21 136.27,141.17 136.27,145.57 136.59,145.88 136.59,152.25 v1(136.94,152.61)
REFCLK1P: length 3.2
  TOP w0.107: J5.28 136.14,148.65 136.39,148.9 136.39,149.7 R39.1 136.39,150.19 136.39,150.47 R726.1
REFCLK1P_R: length 63.4
  TOP w0.107: v1(136.08,152.61) 136.26,152.43 136.26,151.92 R726.2 ; U34.AE9 v1(139.16,102.59)
  L12_SIG4 w0.076: v1(136.08,152.61) 136.31,152.38 136.31,146 135.99,145.68 135.99,141.06 136.96,140.09 136.96,136.1 128.72,127.86 128.72,111.65 129.97,110.39 129.97,106.02 131.79,104.2 131.79,104.2 131.96,104.03 135.2,104.03 136.06,103.17 137.82,103.17 137.99,103.01 138.74,103.01 v1(139.16,102.59)
RESET_SOC_MPU: length 345.7
  L03_SIG1 w0.084: v1(187.41,170.83) 185.19,173.05 168.63,173.05 167.23,171.65 167.23,171.04 163.8,167.61 159.83,167.61 158.57,168.87 158.57,172.52 156.08,175.01 132.38,175.01 131.11,176.28 127.41,176.28 126.97,175.84 121.37,175.84 120.85,175.33 120.85,169.85 121.28,169.42 121.28,167.77 120.52,167 104.14,167 101.09,163.96 76.45,163.96 71.3,158.8 36.88,158.8 33.17,155.09 33.17,143.99 35.92,141.25 35.92,127.53 39.62,123.83 39.62,111.52 40.54,110.61 40.54,69.14 48.72,60.96 56.32,60.96 71.45,45.83 71.45,22.91 76.2,18.16 76.2,14.86 77.13,13.93 v1(79.27,13.93)
  BOTTOM w0.132: U59.D1 v1(187.41,170.83) C682.1 ; U110.12 v1(79.27,13.93)
RESETSTATZ: length 94.1
  TOP w0.132: U34.D19 v1(156.76,93.79) ; U48.2 v1(153.57,52.87)
  L03_SIG1 w0.084: v1(156.76,93.79) 156.36,93.39 156.36,91.27 156.07,90.98 155.03,90.98 154.74,90.7 154.72,90.68 154.72,90.44 154.45,90.16 154.2,90.16 153.92,89.88 153.92,86.21 153.09,85.37 153.09,81.05 153.96,80.18 153.96,56.94 154.48,56.41 154.48,53.78 v1(153.57,52.87)
  BOTTOM w0.122: 159.77,94.95 159,94.19 157.16,94.19 v1(156.76,93.79)
  BOTTOM w0.132: 159.77,94.95 161.44,96.62 161.44,98.95 163.57,101.08 163.57,108.45 165.09,109.97 171.51,109.97 TP48.1 172.52,108.97 R779.2 ; U116.2 168.99,55.63 168.68,55.32 165.46,55.32 163.96,56.82 157.52,56.82 v1(153.57,52.87)
RT: length 5.3
  TOP w0.132: U14.3 80.82,140.11 81.45,139.48 R65.1
SEL_XDS: length 81.2
  TOP w0.132: v1(90.42,86.68) 90.04,86.29 86.64,86.29 85.7,87.23 U36.4 v1(85.7,88.22)
  L12_SIG4 w0.084: v1(85.7,88.22) 79.3,81.82 79.3,73.02 64.78,58.51 v1(44.32,58.51)
  BOTTOM w0.132: U98.15 54,53.55 53.78,53.34 ; U98.14 54.07,53.05 53.78,53.34 ; 53.78,53.34 50.61,53.34 45.44,58.51 v1(44.32,58.51) 44.03,58.8 U97.4 ; U87.6 90.82,86.81 90.69,86.68 v1(90.42,86.68)
SEL_XDS110_INV: length 158.4
  TOP w0.132: U41.1 98.8,75.05 98.93,74.93 v1(98.93,73.15) ; 108.33,63.82 107.95,63.82 106.62,65.15 106.62,67.21 108.62,69.22 U42.15 v1(108.62,71.52) ; 108.33,63.82 108.59,63.56 U43.15 ; 108.33,63.82 108.57,64.06 U43.14 ; v1(98.93,77.14) 98.93,78.88 98.76,79.04 U39.1 ; R215.1 R216.1 ; R215.1 U36.2 ; R215.1 84.27,84.21 83.82,83.76 v1(83.82,82.72) ; J13.8 v1(103.07,95.12)
  L05_SIG2 w0.084: v1(98.93,77.14) 98.6,77.47 95.5,77.47 89.79,83.19 84.29,83.19 v1(83.82,82.72)
  L10_SIG3 w0.084: v1(98.93,73.15) 94.87,69.1 77.6,69.1 66.93,58.43 65.29,58.43 60.2,53.34 60.2,49.92 v1(57.97,47.69)
  L12_SIG4 w0.084: v1(48.38,38.04) 47.69,38.73 47.69,47.24 48.6,48.16 57.5,48.16 v1(57.97,47.69)
  BOTTOM w0.132: U103.6 49.09,38.75 v1(48.38,38.04) ; v1(98.93,73.15) v1(98.93,77.14) ; v1(98.93,73.15) U92.1 ; v1(98.93,73.15) 101.34,70.74 107.84,70.74 v1(108.62,71.52) ; v1(98.93,77.14) 98.93,79.51 97.73,80.71 97.73,86.24 97.95,86.47 J32.58 101.01,86.47 101.6,87.06 101.6,93.34 101.92,93.66 102.74,93.66 103.07,93.99 v1(103.07,95.12) ; v1(98.93,77.14) U90.1 ; v1(57.97,47.69) 57.39,47.11 U101.4
SERDES_BRD_DET: length 152.8
  TOP w0.132: J5.45 146.54,144.27 v1(145.74,143.47) ; v1(88.1,63.21) U46.6 88.1,65.54 87.38,66.26 R236.1
  L12_SIG4 w0.084: v1(88.1,63.21) 88.54,62.78 93.71,62.78 103.82,72.89 104.91,72.89 112.32,80.31 112.32,103.4 112.9,103.99 120.04,103.99 123.01,106.96 123.01,125.3 134.83,137.12 134.83,140.04 135.24,140.45 135.24,142.97 131.38,146.83 131.38,152.47 134.45,155.54 144.21,155.54 146.13,153.62 146.13,148.16 145.1,147.13 145.1,144.11 v1(145.74,143.47)
SOC_DDR_VREFCA: length 39.4
  TOP w0.254: U34.F12 v1(155.16,100.19) ; R728.2 176.75,118.53 v1(176.67,118.61)
  L12_SIG4 w0.127: 159.57,104.58 154.99,104.58 154.76,104.35 154.76,100.58 v1(155.16,100.19)
  L12_SIG4 w0.254: v1(176.67,118.61) 176.67,117.63 167.35,108.31 163.3,108.31 159.57,104.58
  BOTTOM w0.122: v1(155.16,100.19) 155.55,100.58 156.11,100.58 156.35,100.35 156.35,98.43 156.17,98.25 C505.1 C504.1
SOC_DVDD1V8: length 21.2
  TOP w0.254: U34.R8 v1(147.16,103.39) ; U34.Y21 v1(143.16,92.19) ; U34.T20 v1(146.36,92.99) ; U34.W20 v1(143.96,92.99) ; U34.R6 v1(147.16,104.99) ; U34.F20 v1(155.16,92.99) ; U34.AB19 v1(141.56,93.79) ; U34.H19 v1(153.56,93.79) ; U34.N8 v1(149.56,103.39) ; U34.AB21 v1(141.56,92.19) ; U34.P9 v1(148.76,102.59) ; U34.T21 v1(146.36,92.19) ; U34.T7 v1(146.36,104.19) ; U34.V23 v1(144.76,90.59) ; U34.U20 v1(145.56,92.99) ; U34.U22 v1(145.56,91.39) ; U34.N6 v1(149.56,104.99) ; U34.AB23 v1(141.56,90.59) ; U34.AA20 v1(142.36,92.99) ; U34.W22 v1(143.96,91.39) ; U34.P7 v1(148.76,104.19) ; U34.G20 v1(154.36,92.99) ; U34.H21 v1(153.56,92.19) ; U34.AC18 v1(140.76,94.59) ; U34.Y23 v1(143.16,90.59) ; U34.V21 v1(144.76,92.19) ; U34.AA22 v1(142.36,91.39) ; U34.T9 v1(146.36,102.59) ; U34.Y20 v1(143.16,92.99)
  L03_SIG1 w0.122: v1(149.56,103.39) 149.15,102.98 146.75,102.98 v1(146.36,102.59)
  BOTTOM w0.203: v1(146.36,92.99) 146.36,93.02 C547.1 ; v1(143.16,92.99) 143.31,93.15 C548.1
  BOTTOM w0.254: C435.1 147.2,103.34 v1(147.16,103.39)
  vias: v1(170.55,93.65) v1(170.55,92.71) v1(184.98,74.55) v1(184.98,73.55) v1(185.99,74.55) v1(185.99,73.55) v1(187.01,74.55) v1(187.01,73.55) v1(188.02,74.55) v1(188.02,73.55)
SOC_DVDD3V3: length 51.4
  TOP w0.254: U34.N22 v1(149.56,91.39) ; U34.AA18 v1(142.36,94.59) ; U34.N20 v1(149.56,92.99) ; U34.G15 v1(154.36,96.99) ; U34.U8 v1(145.56,103.39) ; U34.H16 v1(153.56,96.19) ; U34.G18 v1(154.36,94.59) ; U34.AB11 v1(141.56,100.99) ; U34.U6 v1(145.56,104.99) ; U34.AB17 v1(141.56,95.39) ; U34.Y7 v1(143.16,104.19) ; U34.AC10 v1(140.76,101.79) ; U34.P21 v1(148.76,92.19) ; U34.V7 v1(144.76,104.19) ; U34.W8 v1(143.96,103.39) ; U34.AA21 v1(142.36,92.19) ; U34.R22 v1(147.16,91.39) ; U34.R20 v1(147.16,92.99)
  L03_SIG1 w0.203: v1(126.56,102.62) 124.9,102.62 120.98,106.54 120.98,115.25 121.3,115.57 121.3,130.02 125.46,134.19 v1(127.57,134.19)
  L06_PWR1 w0.254: 142.62,94.87 142.36,94.6 v1(142.36,94.59)
  BOTTOM w0.254: FL13.1 154.16,94.78 v1(154.36,94.59) ; C560.1 142.38,92.19 v1(142.36,92.19) ; R395.2 v1(127.57,134.19) ; C506.1 154.34,97 v1(154.36,96.99)
  vias: v1(116.36,107.42) v1(116.36,106.63) v1(117.37,107.42) v1(117.37,106.63) v1(118.39,107.42) v1(118.39,106.63) v1(126.56,103.63) v1(127.57,103.63) v1(127.57,102.62) v1(127.57,99.57) v1(127.57,98.55) v1(128.59,99.57) v1(128.59,98.55)
SOC_EMU0: length 175
  TOP w0.132: U34.AA2 v1(142.36,108.19)
  L03_SIG1 w0.084: v1(89.47,86.69) 90.59,87.81 90.59,98.7 93.46,101.58 101.6,101.58 103.63,103.61 103.63,108.81 102.81,109.64 v1(102.81,118.4)
  L05_SIG2 w0.084: v1(142.36,108.19) 142.75,108.58 142.75,109.6 142.75,109.6 142.75,112 141.97,112.77 141.97,113.51 140.65,114.83 137.25,114.83 136.59,114.17 133.81,114.17 132.91,113.27 125.08,113.27 123.73,114.63 114.84,114.63 113.44,116.03 113.44,118.07 111.92,119.59 110.11,119.59 109.56,119.03 109.3,119.03 103.44,119.03 v1(102.81,118.4)
  L12_SIG4 w0.084: v1(49.46,38.1) 48.99,37.63 47.97,37.63 47.38,38.21 47.38,47.37 49.54,49.52 62.49,49.52 63.75,50.79 63.75,57.05 79.6,72.9 79.6,81.45 84.84,86.69 v1(89.47,86.69)
  BOTTOM w0.132: U87.5 89.63,87.54 89.47,87.38 v1(89.47,86.69) ; v1(49.46,38.1) 49.61,38.25 U103.5
SOC_EMU1: length 163.1
  TOP w0.132: U34.AA1 v1(142.36,108.99)
  L03_SIG1 w0.084: v1(103.76,118.43) 103.76,117.49 103.11,116.84 103.11,109.76 103.94,108.94 103.94,103.48 101.73,101.27 93.59,101.27 90.95,98.63 90.95,92.58 92.6,90.93 92.6,88.57 91.86,87.83 91.86,85.19 91.55,84.88 90.66,84.88 v1(90.25,85.29)
  L05_SIG2 w0.084: v1(103.76,118.43) 104.22,118.43 104.47,118.68 109.79,118.68 110.39,119.28 111.79,119.28 113.13,117.94 113.13,115.91 114.87,114.17 123.83,114.17 125.03,112.97 133.03,112.97 133.94,113.87 136.71,113.87 137.37,114.53 140.52,114.53 141.07,113.98 141.07,112.99 142.38,111.68 142.38,109.41 142.36,109.38 v1(142.36,108.99)
  L12_SIG4 w0.084: v1(90.25,85.29) 84.3,85.29 80.21,81.2 80.21,72.64 64.36,56.79 64.36,50.39 57.32,43.35 56.59,43.35 54.28,41.04 v1(54.28,38.13)
  BOTTOM w0.132: v1(54.28,38.13) 54.16,38.25 U103.4 ; U87.4 90.32,85.29 90.25,85.29 v1(90.25,85.29)
SOC_FT4232_MCU_UART1_CTS_1V8: length 8.4
  TOP w0.132: U12.9 115.18,151.32 115.31,151.45 117.34,151.45 118.64,152.75 118.64,155.38 118.9,155.65 U8.2
SOC_FT4232_MCU_UART1_RX_1V8: length 8.9
  TOP w0.132: U12.8 116.22,150.51 116.52,150.81 117.31,150.81 120.89,154.39 120.89,155.02 v1(120.49,155.42)
  BOTTOM w0.132: U65.2 120.21,155.15 v1(120.49,155.42)
SOC_FT4232_WKUP_UART0_CTS_3V3: length 7.3
  TOP w0.132: U21.9 113.34,120.28 113.73,119.89 113.73,115.17 113.42,114.86 U23.2
SOC_FT4232_WKUP_UART0_RX_3V3: length 6.1
  TOP w0.132: U21.8 112.01,119.1 112.27,118.84 112.27,117.09 111.67,116.49 111.67,115.5 v1(112.07,115.09)
  BOTTOM w0.132: v1(112.07,115.09) 112.35,115.36 U83.2
SOC_I2C0_SCL: length 337.3
  TOP w0.132: J16.21 53.43,72.17 v1(52.93,72.67) ; U34.D20 v1(156.76,92.99)
  L03_SIG1 w0.084: v1(60.24,111.6) 58.36,109.73 48.01,109.73 42.89,104.61 J33.3 41.76,94.12 41.76,78.51 46.86,73.41 52.19,73.41 v1(52.93,72.67) 52.47,72.21 52.47,68.76 58.75,62.48 58.75,59.8 72.02,46.53 72.02,24.6 v1(77.79,18.83)
  L05_SIG2 w0.084: v1(159.19,68.01) 158.32,68.88 136.74,68.88 135.03,67.17 135.03,66.92 135.03,58.88 128.56,52.41 125.89,52.41 121.16,57.15 121.16,63.88 115.8,69.24 55.42,69.24 53.39,71.27 53.39,72.21 v1(52.93,72.67)
  L12_SIG4 w0.084: v1(156.76,92.99) 157.16,92.58 157.16,92.06 157.4,91.82 157.73,91.82 158.91,90.64 160.18,90.64 163.79,87.03 163.79,86.83 163.79,73.62 161.02,70.85 161.02,70.32 160.96,70.26 160.96,69.41 159.93,68.38 159.57,68.38 v1(159.19,68.01)
  BOTTOM w0.132: v1(159.19,68.01) 158.81,67.63 R586.2 ; U84.15 v1(60.24,111.6) ; U110.19 78.33,18.74 78.23,18.83 v1(77.79,18.83) ; U91.6 90,79.77 87.89,81.88 70.19,81.88 63.1,74.79 55.05,74.79 v1(52.93,72.67)
SOC_I2C0_SDA: length 340.9
  TOP w0.132: J16.23 v1(52.93,71.75) ; U34.C21 v1(157.56,92.19)
  L03_SIG1 w0.084: v1(77.79,19.87) 72.33,25.33 72.33,46.66 59.05,59.93 59.05,62.61 52.93,68.74 v1(52.93,71.75) 53.34,72.16 53.34,72.84 52.46,73.71 46.99,73.71 42.13,78.57 42.13,87.08 44.02,88.98 44.02,91.58 J33.2 44.45,94.27 44.45,105.74 48.12,109.4 58.73,109.4 60.71,111.38 60.71,114.12 v1(60.24,114.59)
  L05_SIG2 w0.084: v1(160.11,68.03) 159.68,67.6 158.71,67.6 157.73,68.58 136.91,68.58 135.33,67.01 135.33,58.76 128.68,52.11 125.77,52.11 120.85,57.02 120.85,63.68 120.67,63.86 115.6,68.94 55.29,68.94 52.93,71.3 v1(52.93,71.75)
  L12_SIG4 w0.084: v1(157.56,92.19) 157.82,92.19 159.14,90.88 160.08,90.88 160.33,90.88 164.03,87.18 164.03,73.31 161.8,71.07 161.8,69.58 160.24,68.03 v1(160.11,68.03)
  BOTTOM w0.132: R585.2 159.83,67.75 v1(160.11,68.03) ; v1(52.93,71.75) 52.53,72.15 52.53,72.98 54.61,75.06 62.99,75.06 70.08,82.14 88.14,82.14 89.24,81.04 U91.5 ; U84.2 v1(60.24,114.59) ; v1(77.79,19.87) 78.21,19.44 79.53,19.44 79.77,19.2 U110.20
SOC_I2C1_SCL: length 113.1
  TOP w0.132: U34.B21 v1(158.36,92.19)
  L12_SIG4 w0.084: v1(158.36,92.19) 158.36,92.09 159.26,91.19 160.5,91.19 164.34,87.35 164.34,73.28 164.13,73.07 162.03,70.98 162.03,69.48 160.66,68.1 160.66,67.69 160.91,67.44 162.06,67.44 162.46,67.84 162.46,68.06 162.81,68.41 163.49,68.41 v1(163.89,68.01) 166.24,65.66 166.24,63.88 172.85,57.28 172.85,51.94 173.46,51.33 173.46,46.71 174.37,45.8 174.37,40.89 176.53,38.73 176.53,33.15 178.31,31.37 182.63,31.37 196.34,17.65 199.04,17.65 v1(199.58,18.2)
  BOTTOM w0.132: TP67.1 195.81,18.2 v1(199.58,18.2) 200.08,17.7 J38.26 ; R581.2 v1(163.89,68.01)
SOC_I2C1_SDA: length 117.8
  TOP w0.132: U34.E21 v1(155.96,92.19)
  L12_SIG4 w0.084: v1(155.96,92.19) 156.35,91.8 156.87,91.8 157.19,91.48 157.19,91.24 157.4,91.02 157.87,91.02 158.48,90.41 159.91,90.41 163.56,86.76 163.56,73.77 160.79,71 160.79,70.42 160.72,70.36 160.72,69.5 159.83,68.62 159.28,68.62 158.75,68.09 158.75,67.34 159.03,67.06 162.49,67.06 162.98,67.55 v1(162.98,68.01) 165.48,65.51 165.48,64.21 170.13,59.56 170.13,55.46 171.43,54.15 171.43,40.33 175.26,36.5 175.26,30.35 176.53,29.08 178.44,30.99 182.63,30.99 196.28,17.34 198.94,17.34 v1(199.58,16.7)
  BOTTOM w0.132: v1(162.98,68.01) 162.98,67.86 162.88,67.75 R582.2 ; J38.27 200.08,17.2 v1(199.58,16.7) 199.2,16.32 TP68.1
SOC_I2C2_SCL: length 504.7
  TOP w0.132: v1(183.21,161.65) 183.96,162.4 U3.5 ; U2.5 157.48,166.29 158,165.77 158,162.86 156.9,161.76 155.86,161.76 v1(155.36,161.26) ; U27.5 113.28,109.56 113.51,109.79 114.54,109.79 114.78,109.56 U27.2 114.78,107.56 v1(115.28,107.06) ; U34.T27 v1(146.36,87.39) ; R325.1 v1(112.09,24.9) ; U44.1 v1(172.17,63.5)
  L03_SIG1 w0.084: v1(183.21,161.65) 183.48,161.38 185.56,161.38 185.93,161.01 185.93,157.35 176.69,148.11 175.59,148.11 v1(175.18,148.52) ; v1(149.78,153.35) 150.19,153.76 150.87,153.76 151.1,153.52 151.1,151.36 149.73,149.99 149.73,148.76 149.25,148.28 134.24,148.28 v1(131.83,150.69) 131.51,150.36 126.97,150.36 126.47,149.87 118.47,149.87 117.63,149.03 113.46,149.03 110.72,146.29 110.72,133.49 109.08,131.85 109.08,130.41 109.28,130.2 109.28,128.79 108.64,128.15 108.64,124.41 114.43,118.62 114.43,107.91 v1(115.28,107.06) 111.96,103.75 111.96,102.21 115.14,99.03 115.14,95.58 112.52,92.96 112.52,61.04 109.48,57.99 109.48,49.15 105.66,45.34 105.66,42.55 104.56,41.44 104.56,31.33 110.99,24.9 v1(112.09,24.9) 112.52,24.47 112.52,14.3 v1(116.15,10.67)
  L05_SIG2 w0.084: v1(149.78,153.35) 150.19,152.95 150.87,152.95 151.79,153.87 151.79,158.73 152.89,159.83 153.93,159.83 v1(155.36,161.26) ; v1(145.47,77.79) 146.73,79.05 146.73,87.02 v1(146.36,87.39)
  L10_SIG3 w0.084: v1(172.17,63.5) 167.38,63.5 164.15,60.26 152.59,60.26 148.74,64.11 148.08,64.11 146.76,62.79 146.76,60.73 144.08,58.05 144.03,58.05 143.61,57.63 142.44,57.63 v1(142.12,57.95) ; v1(175.18,148.52) 173.66,146.99 166.18,146.99 v1(164.9,148.27) 161.48,148.27 158.45,151.3 151.83,151.3 v1(149.78,153.35)
  L12_SIG4 w0.084: v1(145.47,77.79) 147,76.26 147,74.68 147.64,74.04 151.07,74.04 151.6,73.51 151.6,71.4 146.95,66.75 146.95,59.12 145.79,57.95 v1(142.12,57.95) 140.76,56.6 140.76,49.38 139.32,47.94 137.1,47.94 135.38,46.23 135.38,41.72 135.98,41.12 142.67,41.12 146.42,37.37 146.42,23.83 148.49,21.76 148.49,13.12 142.74,7.37 124.99,7.37 122.02,10.34 116.48,10.34 v1(116.15,10.67)
  BOTTOM w0.132: v1(112.09,24.9) 113.14,23.85 120.42,23.85 120.93,23.34 120.98,23.34 122.43,21.89 122.43,20.51 121.74,19.82 U126.7 ; TP73.1 131.83,147.26 v1(131.83,150.69) 132.33,150.19 U68.5 ; v1(164.9,148.27) 165.4,147.77 U70.5 ; v1(172.17,63.5) 172.74,62.93 174.81,62.93 177.28,65.4 183.29,65.4 183.67,65.02 185.48,65.02 185.99,65.53 185.99,66.76 185.78,66.97 R592.2 U93.5 ; U67.5 150.28,152.85 v1(149.78,153.35) ; U69.5 175.68,148.02 v1(175.18,148.52) 176.18,149.52 U69.2 ; U89.1 v1(145.47,77.79)
SOC_I2C2_SDA: length 488.1
  TOP w0.132: v1(185.55,160.76) 185.46,160.84 U3.2 185.46,163.66 185.29,163.83 184.59,163.83 184.46,163.7 U3.4 ; U34.R25 v1(147.16,88.99) ; v1(113.28,107.06) 113.78,107.55 U27.4 ; U2.4 157.48,165.79 157.67,165.6 157.67,163.21 157.16,162.7 155.65,162.7 v1(155.3,162.35) ; R326.1 v1(112.09,22.36) ; U44.6 v1(174.57,63.5)
  L03_SIG1 w0.084: v1(116.15,9.93) 115.7,9.93 112.09,13.54 v1(112.09,22.36) 112.09,23.16 104.25,31 104.25,41.77 105.28,42.8 105.28,45.47 109.17,49.36 109.17,58.12 112.27,61.21 112.27,93.17 114.83,95.73 114.83,98.91 111.71,102.03 111.71,105.49 v1(113.28,107.06) 114.19,107.97 114.19,118.52 108.33,124.38 108.33,128.27 108.9,128.84 108.9,130.16 108.84,130.22 108.84,131.95 110.48,133.59 110.48,146.49 114.68,150.69 117.59,150.69 118.75,151.84 131.59,151.84 v1(132.75,150.69) 134.85,148.58 148.2,148.58 148.72,149.1 148.72,151.37 v1(150.7,153.35) ; v1(185.55,160.76) 185.55,157.41 176.66,148.52 v1(176.1,148.52)
  L05_SIG2 w0.084: v1(147.16,88.99) 146.75,88.58 146.75,87.28 147,87.02 147.45,87.02 147.68,86.79 147.68,85.32 147.02,84.66 147.02,78.54 v1(147.76,77.79) ; v1(155.3,162.35) 153.32,160.38 152.96,160.38 151.2,158.62 151.2,153.86 v1(150.7,153.35)
  L10_SIG3 w0.084: v1(176.1,148.52) 175.69,148.92 174.83,148.92 173.2,147.3 166.79,147.3 v1(165.81,148.27) 165.18,148.9 161.28,148.9 158.58,151.61 152.44,151.61 v1(150.7,153.35) ; v1(142.2,57.04) 141.71,57.53 141.71,58.12 141.95,58.36 143.96,58.36 146.46,60.86 146.46,62.92 147.95,64.41 148.87,64.41 152.72,60.57 164.02,60.57 167.34,63.88 174.18,63.88 v1(174.57,63.5)
  L12_SIG4 w0.084: v1(116.15,9.93) 121.59,9.93 124.51,7.01 142.71,7.01 148.73,13.02 148.73,21.86 146.66,23.93 146.66,37.47 142.7,41.43 136.75,41.43 136.4,41.78 136.4,46.74 137.03,47.37 139.18,47.37 141.07,49.26 141.07,55.91 v1(142.2,57.04) 145.31,57.04 147.26,58.99 147.26,66.62 151.9,71.27 151.9,73.64 151.19,74.35 149.45,74.35 148.17,75.63 148.17,77.38 v1(147.76,77.79)
  BOTTOM w0.132: v1(150.7,153.35) U67.4 ; U93.4 184.37,69.66 184.24,69.53 R593.2 183.85,66.97 183.71,66.83 183.71,66.1 183.27,65.67 177.18,65.67 176.02,64.52 175.59,64.52 v1(174.57,63.5) ; U70.2 165.94,149.27 165.81,149.14 v1(165.81,148.27) U70.4 ; U68.4 v1(132.75,150.69) 132.3,151.13 131.06,151.13 130.75,150.81 130.75,148.53 TP74.1 ; v1(176.1,148.52) U69.4 ; v1(112.09,22.36) 113.23,23.51 120.33,23.51 122.08,21.75 122.08,21.08 121.47,20.47 U126.6 ; U89.6 v1(147.76,77.79)
SOC_I2C2_TA_SCL: length 22.4
  BOTTOM w0.132: J41.36 121.35,5.93 120.88,5.46 118.95,5.46 117.42,6.99 117.42,19.63 117.24,19.82 U126.2 115.57,19.82 115.19,20.19 R775.2
SOC_I2C2_TA_SDA: length 18.6
  BOTTOM w0.132: R774.2 114.75,20.47 U126.3 117.53,20.47 117.86,20.14 117.86,14.65 120.34,12.16 120.34,10.03 120.35,10.03 J41.38
SOC_MAIN_UART0_CTS_3V3: length 52.8
  TOP w0.132: v1(112.12,130.73) 111.25,130.73 111.09,130.57 U19.9 ; U34.AG11 v1(137.56,100.19)
  L03_SIG1 w0.084: v1(137.56,100.19) 137.31,100.19 136.92,99.8 136.12,99.8 135.81,99.49 130.05,99.49 129.57,99.97 126.57,99.97 120.19,106.35 120.19,126.7 116.46,130.43 112.42,130.43 v1(112.12,130.73)
SOC_MAIN_UART0_RTS_3V3: length 59.8
  TOP w0.132: U34.AD11 v1(139.96,100.99) ; U19.7 112.26,129.41 112.31,129.46 112.95,129.46 113.06,129.35 113.08,129.35 v1(113.4,129.04)
  L03_SIG1 w0.084: v1(113.4,129.04) 112.97,129.47 112.3,129.47 112.07,129.23 112.07,126.28 113.44,124.9 118.05,124.9 119.68,123.27 119.68,105.99 124.02,101.66 124.02,100.52 126.44,98.09 135.24,98.09 135.44,98.3 136.4,98.3 136.51,98.18 136.92,98.18 137.16,98.42 137.16,98.93 137.23,99 139.32,99 139.56,99.25 139.56,100.38 139.83,100.65 139.83,100.86 v1(139.96,100.99)
SOC_MAIN_UART0_RX_3V3: length 53.5
  TOP w0.132: U19.8 112.41,129.81 113.16,130.55 v1(113.16,130.91) ; U34.AF11 v1(138.36,100.99)
  L03_SIG1 w0.084: v1(113.16,130.91) 116.48,130.91 120.99,126.4 120.99,115.85 120.68,115.53 120.68,106.3 126.01,100.97 129.13,100.97 130.25,99.85 135.69,99.85 136.42,100.58 137.95,100.58 v1(138.36,100.99)
SOC_MAIN_UART0_TX_3V3: length 54
  TOP w0.132: U19.6 v1(112.49,129.01) ; U34.AE11 v1(139.16,100.99)
  L03_SIG1 w0.084: v1(139.16,100.99) 138.76,100.6 138.76,100.05 138.5,99.78 137.37,99.78 137.15,99.55 137.15,99.23 136.92,99 136.26,99 136.14,99.11 125.86,99.11 124.32,100.65 124.32,101.79 119.94,106.17 119.94,125.81 118.24,127.51 113.99,127.51 v1(112.49,129.01)
SOC_MAIN_UART1_RX_1V8: length 86.7
  TOP w0.132: U34.AE23 v1(139.16,90.59) ; U26.7 87.98,112.38 v1(87.33,113.03)
  L05_SIG2 w0.084: v1(139.16,90.59) 139.16,90.39 138.75,89.98 138.75,88.71 138.62,88.58 136.43,88.58 135.86,88.01 135.15,88.01 133.53,86.39 131.09,86.39 127.13,82.42 119.66,82.42 111.66,90.43 111.66,101.69 104.84,108.51 96.33,108.51 93.41,105.59 87.12,105.59 85.78,106.93 85.78,111.48 v1(87.33,113.03)
SOC_MAIN_UART1_TX_1V8: length 93.2
  TOP w0.132: U34.AD23 v1(139.96,90.59) ; U26.4 v1(89.93,111.99)
  L05_SIG2 w0.084: v1(139.96,90.59) 139.57,90.21 139.57,89.96 139.56,89.95 139.56,88.85 139.32,88.6 139.01,88.6 138.76,88.35 138.76,88.03 138.52,87.78 136.42,87.78 136.34,87.7 135.27,87.7 133.65,86.08 131.21,86.08 127.25,82.12 119.54,82.12 111.35,90.3 111.35,101.56 104.71,108.2 96.65,108.2 93.66,105.22 87.06,105.22 85.47,106.81 85.47,112.33 87.19,114.05 89.92,114.05 90.39,113.57 90.39,112.44 v1(89.93,111.99)
SOC_MCU_SCL: length 354.2
  TOP w0.132: J5.2 156.94,150.21 157.1,150.37 U9.6 v1(157.1,152.39)
  L03_SIG1 w0.084: v1(157.1,152.39) 158.71,152.39 164.21,146.89 177.99,146.89 179.27,148.17 193.22,148.17 199.39,141.99 199.39,80.84 190.13,71.58 190.13,40.02 186.69,36.58 186.69,28.83 187.58,27.94 187.58,24.26 186.5,23.18 170.75,23.18 169.8,24.13 169.8,26.29 170.56,27.05 174.12,27.05 175.13,28.07 175.13,31.37 173.99,32.51 J44.2 173.99,34.8 172.64,36.14 161.67,36.14 160.94,35.41 160.94,34.93 v1(160.54,34.52) 160.54,20.58 158.43,18.48 142.61,18.48 v1(142.07,19.01) 141.62,19.01 140.26,17.65 138.89,17.65 136.93,15.7 134.47,15.7 134.04,16.13 126.59,16.13 113.22,29.5 113.22,36.86 112.93,37.15 112.93,46.75 121.34,55.16 121.34,75.28 v1(124.73,78.68)
  BOTTOM w0.132: v1(160.54,34.52) 161.04,35.02 J35.32 ; TP69.1 157.1,151.73 v1(157.1,152.39) ; U111.20 v1(142.07,19.01) ; R545.2 v1(124.73,78.68)
SOC_MCU_SCL_R: length 102.4
  TOP w0.132: U34.AD8 v1(139.96,103.39)
  L12_SIG4 w0.084: v1(139.96,103.39) 139.96,103.38 140.31,103.02 142.45,103.02 142.75,102.72 142.75,100.87 143.06,100.56 149.76,100.56 149.99,100.33 149.99,94.44 150.2,94.22 150.51,94.22 150.79,93.94 150.79,91.24 151.06,90.96 155.31,90.96 155.59,90.68 155.59,90.44 155.86,90.16 156.11,90.16 156.39,89.88 156.39,88.84 156.6,88.62 160.43,88.62 162.56,86.49 162.56,77.09 160.91,75.44 160.91,73.03 158.88,70.99 158.88,70.06 156.99,68.17 156.99,66.32 158.54,64.77 158.74,64.77 163.83,64.77 168.66,59.94 168.66,56.26 170.94,53.98 170.94,40.03 172.21,38.76 172.21,33.91 J44.1
SOC_MCU_SDA: length 355.9
  TOP w0.132: J5.3 156.14,150.06 155.83,150.37 U9.5 v1(155.83,152.39)
  L03_SIG1 w0.084: v1(124.73,79.69) 121.03,76 121.03,55.29 112.67,46.93 112.67,36.98 112.92,36.73 112.92,29.37 126.44,15.85 133.96,15.85 134.37,15.44 137.11,15.44 138.84,17.18 v1(140.24,17.18) 141.22,18.16 159.7,18.16 162.05,20.51 162.05,34.92 v1(161.54,35.43) 161.54,35.43 162.02,35.91 171.1,35.91 172.72,34.29 172.72,32 173.99,30.73 J45.2 172.34,27.43 170.05,27.43 169.29,26.67 169.29,23.62 170.18,22.73 186.56,22.73 189.23,25.4 189.23,34.93 188.85,35.31 188.85,38.23 190.44,39.81 190.44,71.45 199.69,80.71 199.69,142.15 193.37,148.47 179.14,148.47 177.87,147.19 164.72,147.19 159.12,152.8 156.24,152.8 v1(155.83,152.39)
  BOTTOM w0.132: J35.34 v1(161.54,35.43) ; R538.2 v1(124.73,79.69) ; TP70.1 155.83,151.87 v1(155.83,152.39) ; U111.18 v1(140.24,17.18)
SOC_MCU_SDA_R: length 108
  TOP w0.132: U34.AD7 v1(139.96,104.19)
  L12_SIG4 w0.084: v1(139.96,104.19) 140.23,104.19 140.6,103.82 143.32,103.82 143.59,103.56 143.59,101.64 143.8,101.42 150.45,101.42 150.72,101.14 150.72,94.5 151.06,94.16 151.31,94.16 151.59,93.88 151.59,91.98 151.8,91.76 155.38,91.76 155.58,91.57 155.58,91.25 155.8,91.02 156.05,91.02 156.39,90.68 156.39,90.44 156.66,90.16 156.91,90.16 157.19,89.88 157.19,89.64 157.41,89.41 160.02,89.41 162.94,86.49 162.94,76.33 161.79,75.17 161.79,73.14 159.72,71.08 159.72,69.5 159.31,69.09 158.24,69.09 157.23,68.07 157.23,66.42 158.64,65.01 163.93,65.01 168.89,60.04 168.89,56.36 171.2,54.06 171.2,40.23 172.78,38.64 172.78,30.42 J45.1
SOC_MCU_UART1_CTS_1V8: length 82.9
  TOP w0.132: U34.P1 v1(148.76,108.99) ; v1(121.81,154.51) 121.95,154.65 U8.5
  L03_SIG1 w0.084: v1(121.81,154.51) 122.3,154.99 127.05,154.99 128.81,156.75 150.73,156.75 151.43,156.05 151.43,150.58 152.71,149.3 152.71,144.52 152.03,143.84 152.03,141.43 153.6,139.87 153.6,127.68 151.42,125.5 151.42,113.97 150.91,113.46 150.91,112.81 149.23,111.12 149.23,109.46 v1(148.76,108.99)
SOC_MCU_UART1_RTS_1V8: length 105.2
  TOP w0.132: v1(117.49,156.23) 117.05,156.67 116.4,156.67 116.36,156.63 U6.7 ; U34.N3 v1(149.56,107.39) ; U12.7 v1(116.58,150.11)
  L03_SIG1 w0.084: v1(117.49,156.23) 119.76,158.49 121.36,158.49 122.05,159.18 127.81,159.18 128.32,159.69 150.06,159.69 152.95,156.8 152.95,151.41 153.96,150.39 153.96,144.45 155.18,143.23 155.18,141.24 158.94,137.48 158.94,127.2 152.65,120.91 152.65,117.73 152.12,117.2 152.12,113.01 149.95,110.83 149.95,109.6 149.95,109.6 149.95,107.78 v1(149.56,107.39)
  BOTTOM w0.132: v1(116.58,150.11) 116.18,150.51 116.18,156.39 116.42,156.62 117.1,156.62 v1(117.49,156.23)
SOC_MCU_UART1_RX_1V8: length 88.2
  TOP w0.132: U34.P4 v1(148.76,106.59)
  L03_SIG1 w0.084: v1(121.82,156.34) 122.54,155.61 127.24,155.61 129.35,157.72 150.19,157.72 151.73,156.18 151.73,150.61 153.02,149.32 153.02,144.39 152.34,143.72 152.34,141.56 154.28,139.62 154.28,138.49 156.06,136.71 156.06,124.75 151.73,120.42 151.73,113.13 149.61,111 149.61,109.22 149.16,108.78 149.16,107 v1(148.76,106.59)
  BOTTOM w0.132: U65.5 122,156.15 v1(121.82,156.34)
SOC_MCU_UART1_TX_1V8: length 97.3
  TOP w0.132: U34.P5 v1(148.76,105.79) ; v1(117.49,150.11) 117.05,149.67 116.4,149.67 116.36,149.71 U12.6 ; U6.6 v1(116.58,156.23)
  L05_SIG2 w0.084: v1(148.76,105.79) 148.36,105.79 147.83,106.33 147.83,109.35 147.75,109.42 147.75,112.34 145.29,114.81 145.29,116.97 144.63,117.62 144.63,119.51 149.91,124.79 149.91,130.66 145.97,134.59 127.2,134.59 123.83,137.97 115.85,137.97 114.13,136.25 112.73,136.25 111.32,137.67 111.32,144.97 115.7,149.35 116.73,149.35 v1(117.49,150.11)
  BOTTOM w0.132: v1(116.58,156.23) 116.58,151.03 v1(117.49,150.11)
SOC_MMC0_CD: length 31.5
  TOP w0.132: v1(176.54,71.64) 175.25,71.64 165.16,81.72 165.16,88.06 163.87,89.36 163.02,89.36 161.76,90.61 159.52,90.61 159.15,90.99 U34.A23
  BOTTOM w0.132: R739.1 177.42,70.76 v1(176.54,71.64)
SOC_MMC0_CLK: length 13.4
  TOP w0.132: R532.1 163.73,80.42 163.73,86.53 161.21,89.06 159.55,89.06 159.48,88.99 158.35,88.99 U34.B25
SOC_MMC0_CMD: length 58.4
  TOP w0.132: U51.M5 v1(161.18,50.36) ; U34.B27 158.35,87.39 159.09,87.39 159.19,87.3 161.47,87.3 162.68,86.09 162.68,79.85 162.48,79.65 159.21,79.65 159,79.45 159,75.98 v1(161.41,73.57)
  L03_SIG1 w0.084: v1(161.41,73.57) 161.41,74.06 162.23,74.88 165.02,74.88 165.53,74.37 165.53,68.91 166.07,68.37 166.07,63.06 166.62,62.51 166.62,58.06 165.91,57.35 163.65,57.35 162.79,56.49 162.79,54.91 163.46,54.24 163.46,51.21 163.01,50.76 161.59,50.76 v1(161.18,50.36)
  BOTTOM w0.132: R625.2 161.38,50.16 v1(161.18,50.36)
SOC_MMC0_DAT0: length 58.3
  TOP w0.132: U51.A3 160.18,58.38 159.07,59.5 v1(159.07,59.55) R264.2 ; v1(162.41,73.57) 162.41,73.27 162.64,73.05 164.41,73.05 164.62,73.25 164.62,73.66 164.49,73.8 163.56,73.8 163.42,73.93 163.42,74.17 163.55,74.3 164.26,74.3 164.38,74.41 164.38,74.63 164.29,74.73 163.35,74.73 163.21,74.87 163.21,75.22 163.34,75.35 164.26,75.35 164.39,75.48 164.39,75.73 164.26,75.86 163.34,75.86 163.21,75.99 163.21,76.24 163.34,76.38 164.26,76.38 164.39,76.51 164.39,76.76 164.26,76.89 163.34,76.89 163.21,77.02 163.21,77.27 163.34,77.4 164.26,77.4 164.39,77.53 164.39,77.78 164.26,77.92 163.34,77.92 163.21,78.05 163.21,86.31 160.99,88.53 159.21,88.53 159.15,88.59 U34.A26
  L03_SIG1 w0.084: v1(159.07,59.55) 160.39,58.23 164.04,58.23 165.42,59.61 165.42,67.93 162.41,70.94 v1(162.41,73.57)
SOC_MMC0_DAT1: length 58.2
  TOP w0.132: U51.A4 160.49,55.51 160.49,58.45 160.21,58.73 v1(160.21,59.55) R265.2 ; U34.E25 v1(155.96,88.99)
  L03_SIG1 w0.084: v1(160.21,59.55) 158.22,61.54 158.22,70.03 158.13,70.12 157.34,70.12 157.25,70.2 157.25,70.5 157.34,70.58 158.13,70.58 158.22,70.67 158.22,70.96 158.13,71.05 157.34,71.05 157.25,71.13 157.25,71.43 157.34,71.51 158.13,71.51 158.22,71.6 158.22,71.89 158.13,71.98 157.34,71.98 157.25,72.06 157.25,72.36 157.34,72.44 158.13,72.44 158.22,72.53 158.22,73.03 157.78,73.47 157.23,73.47 157.15,73.55 157.15,73.85 157.23,73.93 157.78,73.93 157.86,74.02 157.86,74.31 157.78,74.4 157.23,74.4 157.15,74.48 157.15,74.78 157.23,74.86 157.78,74.86 157.86,74.95 157.86,78.31 157.66,78.51 157.3,78.51 157.07,78.28 157.07,76.33 156.85,76.1 156.44,76.1 156.29,76.25 156.29,80.57 156.39,80.67 156.73,80.67 156.81,80.59 156.81,79.46 156.89,79.38 157.19,79.38 157.28,79.46 157.28,80.59 157.36,80.67 157.66,80.67 157.74,80.59 157.74,79.46 157.82,79.38 158.12,79.38 158.21,79.46 158.21,80.59 158.29,80.67 158.8,80.67 158.94,80.81 158.94,82.69 156.35,85.28 156.35,88.6 v1(155.96,88.99)
SOC_MMC0_DAT2: length 58.1
  TOP w0.132: U51.A5 161.18,58.24 v1(162.5,59.55) R267.2 ; U34.C26 v1(157.56,88.19)
  L03_SIG1 w0.084: v1(157.56,88.19) 157.96,88.6 159.77,88.6 159.77,88.6 160.77,88.6 163.08,86.29 163.08,78.89 163,78.8 161.5,78.8 161.42,78.72 161.42,78.42 161.5,78.34 163,78.34 163.08,78.26 163.08,77.96 163,77.88 161.5,77.88 161.42,77.79 161.42,77.49 161.5,77.41 163,77.41 163.08,77.33 163.08,76.21 162.08,75.21 161.49,75.21 161.41,75.29 161.41,76.85 161.32,76.94 161.03,76.94 160.94,76.85 160.94,75.29 160.86,75.21 160.56,75.21 160.48,75.29 160.48,76.85 160.39,76.94 160.1,76.94 160.01,76.85 160.01,75.63 158.82,74.44 158.82,66.73 159.69,65.86 159.69,61.77 160.93,60.53 160.93,59.33 161.16,59.11 162.05,59.11 v1(162.5,59.55)
SOC_MMC0_DAT3: length 58.3
  TOP w0.094: U51.B2 159.44,55.06 159.44,55.5
  TOP w0.132: U34.A25 159.35,89.39 159.55,89.59 161.43,89.59 164.26,86.75 164.26,81.03 166.62,78.66 166.62,75.38 166.76,75.25 167.78,75.25 167.92,75.11 167.92,74.86 167.78,74.73 166.76,74.73 166.62,74.6 166.62,74.34 166.76,74.21 167.05,74.21 167.18,74.08 167.18,73.83 167.05,73.7 166.76,73.7 166.62,73.56 166.62,73.18 166.49,73.05 165.6,73.05 v1(165.1,73.55) ; 159.44,55.5 159.44,56.89 v1(156.78,59.55) R262.2
  L03_SIG1 w0.084: v1(165.1,73.55) 165.1,68.94 165.84,68.2 165.84,62.69 166.3,62.23 166.3,59.4 164.76,57.86 158.47,57.86 v1(156.78,59.55)
SOC_MMC0_DAT4: length 58.2
  TOP w0.094: U51.B3 159.93,55.08 159.93,55.63
  TOP w0.132: 159.93,55.63 159.92,55.63 159.92,57.55 v1(157.92,59.55) R263.2 ; U34.E24 v1(155.96,89.79)
  L03_SIG1 w0.084: v1(157.92,59.55) 156.16,61.31 156.16,67.26 156.25,67.35 157.28,67.35 157.36,67.43 157.36,67.73 157.28,67.81 156.25,67.81 156.16,67.9 156.16,68.19 156.25,68.28 157.28,68.28 157.36,68.36 157.36,68.66 157.28,68.74 156.25,68.74 156.16,68.83 156.16,69.12 156.25,69.21 157.28,69.21 157.36,69.29 157.36,69.59 157.28,69.67 156.25,69.67 156.16,69.76 156.16,72.79 155.83,73.12 155.83,79.43 155.83,79.43 155.09,80.16 155.09,81.98 155.18,82.06 157.68,82.06 157.76,82.14 157.76,82.44 157.68,82.52 155.18,82.52 155.09,82.61 155.09,82.91 155.18,82.99 157.68,82.99 157.76,83.07 157.76,83.37 157.68,83.45 157.01,83.45 156.92,83.54 156.92,84.12 156.84,84.2 156.54,84.2 156.46,84.12 156.46,83.54 156.37,83.45 156.08,83.45 155.99,83.54 155.99,84.12 155.91,84.2 155.61,84.2 155.53,84.12 155.53,83.54 155.44,83.45 155.18,83.45 155.09,83.54 155.09,84.39 155.59,84.89 155.59,89.42 v1(155.96,89.79)
SOC_MMC0_DAT5: length 58.2
  TOP w0.094: U51.B4 160.93,55.06 160.93,55.5
  TOP w0.132: v1(160.41,73.57) 161.32,72.67 167.94,72.67 168.2,72.92 168.2,73.59 168.36,73.75 170.02,73.75 170.15,73.88 170.15,74.13 170.02,74.26 168.33,74.26 168.2,74.39 168.2,74.62 168.36,74.77 170.02,74.77 170.15,74.91 170.15,75.13 170.02,75.26 168.33,75.26 168.2,75.39 168.2,77.62 164.53,81.3 164.53,86.86 161.54,89.85 159.1,89.85 U34.A24 ; R266.2 v1(161.35,59.55) 160.91,59.1 160.91,55.52 160.93,55.5
  L03_SIG1 w0.084: v1(161.35,59.55) 161.35,64.2 160.66,64.9 160.66,73.33 v1(160.41,73.57)
SOC_MMC0_DAT6: length 58.3
  TOP w0.094: U51.B5 161.44,55.08 161.44,55.5
  TOP w0.132: 161.44,55.5 161.45,55.51 161.45,57.36 v1(163.64,59.55) R268.2 ; v1(162.41,74.49) 162.81,74.49 162.94,74.62 162.94,75.46 162.81,75.59 160.69,75.59 160.55,75.72 160.55,75.97 160.69,76.11 162.81,76.11 162.94,76.24 162.94,76.49 162.81,76.62 160.69,76.62 160.55,76.75 160.55,77 160.69,77.13 162.81,77.13 162.94,77.26 162.94,77.51 162.81,77.64 160.69,77.64 160.55,77.78 160.55,78.03 160.69,78.16 162.81,78.16 162.94,78.29 162.94,78.54 162.81,78.67 160.69,78.67 160.55,78.8 160.55,79.05 160.69,79.18 162.81,79.18 162.94,79.32 162.94,86.2 160.88,88.27 159.17,88.27 159.09,88.19 158.36,88.19 U34.B26
  L03_SIG1 w0.084: v1(163.64,59.55) 163.64,65.01 162.51,66.14 162.51,70.15 161.98,70.69 161.98,74.05 v1(162.41,74.49)
SOC_MMC0_DAT7: length 58.2
  TOP w0.094: U51.B6 161.93,55.06 162.31,55.06 162.43,55.18 162.43,55.63
  TOP w0.132: U34.D25 v1(156.76,88.99) ; R269.2 v1(164.78,59.55) 162.56,57.33 162.56,55.75 162.43,55.63
  L03_SIG1 w0.084: v1(156.76,88.99) 157.16,88.58 157.16,84.9 158.6,83.46 160.65,83.46 161.06,83.06 161.06,82.48 160.85,82.27 160.16,82.27 160.08,82.35 160.08,82.8 159.99,82.88 159.69,82.88 159.61,82.8 159.61,82.35 159.53,82.27 159.32,82.27 159.23,82.18 159.23,81.89 159.32,81.8 160.85,81.8 160.93,81.72 160.93,81.42 160.85,81.34 159.32,81.34 159.23,81.26 159.23,80.96 159.32,80.87 160.85,80.87 160.93,80.79 160.93,80.49 160.85,80.41 159.32,80.41 159.23,80.33 159.23,80.03 159.32,79.94 160.82,79.94 160.93,79.83 160.93,79.48 160.66,79.2 159.66,79.2 159.49,79.02 159.49,75.44 158.52,74.47 158.52,66.52 159.31,65.74 159.31,61.37 160.63,60.05 160.63,59.21 161.24,58.6 163.83,58.6 v1(164.78,59.55)
SOC_MMC0_DS: length 46.7
  TOP w0.132: R253.1 v1(154.48,50.55) ; U34.C25 v1(157.56,88.99)
  L03_SIG1 w0.084: v1(157.56,88.99) 157.16,89.38 156.54,89.38 156.36,89.56 156.36,90.04 156.25,90.16 155.74,90.16 155.52,89.94 155.52,89.64 155.35,89.46 155.35,85.04 154.76,84.45 154.76,73 155.12,72.64 155.12,59.23 157.2,57.15 157.2,52.5 155.24,50.55 v1(154.48,50.55)
SOC_MMC0_WP: length 31.9
  TOP w0.132: v1(176.44,70.86) 175.52,70.86 164.9,81.48 164.9,87.1 161.77,90.23 159.39,90.23 159.03,90.59 158.36,90.59 U34.B23
  BOTTOM w0.132: R741.2 R740.1 176.4,70.82 v1(176.44,70.86)
SOC_OSPI_CLK: length 12.3
  TOP w0.132: U34.V1 v1(144.76,108.99)
  L03_SIG1 w0.084: v1(144.76,108.99) 144.76,112.56 142.3,115.01 v1(142.3,119.05)
  BOTTOM w0.132: R430.1 v1(142.3,119.05)
SOC_OSPI_DQ0: length 26.5
  TOP w0.132: U34.U4 v1(145.56,106.59)
  L03_SIG1 w0.084: v1(145.04,119.05) 146.14,120.15 146.14,121.32 145.54,121.92 141.73,121.92 141.1,121.28 141.1,115.44 144.37,112.17 144.37,109.15 144.36,109.15 144.36,107.23 144.59,107 145.15,107 v1(145.56,106.59)
  BOTTOM w0.132: RA8.13 v1(145.04,119.05)
SOC_OSPI_DQ1: length 27.7
  TOP w0.132: U34.U5 v1(145.56,105.79)
  L03_SIG1 w0.084: v1(147.23,118.1) 147.59,118.45 147.59,120.88 147.74,121.03 150.22,121.03 150.37,120.88 150.37,118.15 151.12,117.4 151.12,114.1 150.51,113.49 150.51,113 148.84,111.34 148.84,109.73 148.28,109.16 148.28,107.88 148.27,107.87 148.27,107.85 147.95,107.54 147.95,106.04 147.32,105.4 145.95,105.4 v1(145.56,105.79)
  BOTTOM w0.132: v1(147.23,118.1) 146.54,118.79 RA8.10
SOC_OSPI_DQ2: length 13.4
  TOP w0.132: U34.T2 v1(146.36,108.19)
  L03_SIG1 w0.084: v1(146.36,108.19) 146.36,108.46 145.95,108.87 145.95,112.37 145.44,112.88 145.44,113.64 144.04,115.04 v1(144.04,118.05)
  BOTTOM w0.132: RA8.16 143.47,118.61 v1(144.04,118.05)
SOC_OSPI_DQ3: length 18.8
  TOP w0.132: U34.T3 v1(146.36,107.39)
  L03_SIG1 w0.084: v1(145.1,118.05) 144.53,118.62 144.53,119.35 144.37,119.51 143.54,119.51 143.38,119.35 143.38,114.36 145.16,112.58 145.16,108.83 145.39,108.6 145.72,108.6 145.96,108.36 145.96,108.04 146.36,107.64 v1(146.36,107.39)
  BOTTOM w0.132: v1(145.1,118.05) 144.54,118.61 RA8.14
SOC_OSPI_DQ4: length 15.2
  TOP w0.132: U34.T4 v1(146.36,106.59)
  L03_SIG1 w0.084: v1(144.04,119.05) 144.04,118.62 144.65,118.01 144.65,116.98 144.44,116.77 144.44,115.07 145.74,113.77 145.74,113.08 146.76,112.06 146.76,107 v1(146.36,106.59)
  BOTTOM w0.132: RA8.15 v1(144.04,119.05)
SOC_OSPI_DQ5: length 26.6
  TOP w0.132: U34.T5 v1(146.36,105.79)
  L03_SIG1 w0.084: v1(146.36,105.79) 146.76,106.2 147.35,106.2 147.7,106.55 147.7,107.6 148.05,107.95 148.05,107.97 148.05,107.97 148.05,109.44 148.46,109.86 148.46,111.39 150.2,113.13 150.2,113.61 150.81,114.22 150.81,117.27 150.06,118.02 150.06,120.37 149.91,120.52 148.04,120.52 147.89,120.37 147.89,117.83 147.64,117.58 147.19,117.58 147.03,117.74 146.37,117.74 146.24,117.87 v1(146.24,118.1)
  BOTTOM w0.132: RA8.12 145.54,118.8 v1(146.24,118.1)
SOC_OSPI_DQ6: length 27.5
  TOP w0.132: U34.R2 v1(147.16,108.19)
  L03_SIG1 w0.084: v1(146.04,119.05) 145.51,118.52 145.51,117.09 145.35,116.94 145.35,115.13 145.67,114.81 149.07,114.81 149.23,114.96 149.23,115.54 149.07,115.7 147.38,115.7 147.23,115.85 147.23,116.06 148.26,117.09 150.03,117.09 150.18,116.94 150.18,114.88 149.23,113.92 147.23,113.92 147.08,113.77 147.08,109.87 147.57,109.38 147.57,108.61 v1(147.16,108.19)
  BOTTOM w0.132: RA8.11 v1(146.04,119.05)
SOC_OSPI_DQ7: length 27.5
  TOP w0.132: U34.R3 v1(147.16,107.39)
  L03_SIG1 w0.084: v1(147.1,119.05) 147.1,120.12 146.95,120.27 146.6,120.27 146.44,120.12 146.44,118.88 146.21,118.64 146.07,118.64 145.83,118.4 145.83,117.19 146.3,116.71 147.44,116.71 148.21,117.48 148.21,119.86 148.36,120.02 149.61,120.02 149.76,119.86 149.76,117.9 150.49,117.17 150.49,114.56 149.39,113.46 149.39,112.94 147.83,111.38 147.83,108.06 v1(147.16,107.39)
  BOTTOM w0.132: RA8.9 v1(147.1,119.05)
SOC_PORZ: length 339.5
  TOP w0.132: R299.2 v1(105.12,50.55) ; U34.W5 v1(143.96,105.79) ; U34.E19 v1(155.96,93.79)
  L05_SIG2 w0.084: v1(105.12,50.55) 108.04,53.47 119.89,53.47 124.4,48.96 126.03,48.96 127.25,47.74 140.27,47.74 141.24,48.7 145.61,48.7 147.07,47.24 v1(148.34,47.24) ; v1(176.09,65.34) 177.42,66.67 185.55,66.67 186.57,65.65 196.97,65.65 201.28,69.96 201.28,140.65 191.66,150.27 154.46,150.27 153.67,149.48 v1(151.89,149.48)
  L10_SIG3 w0.084: 153.16,102.87 153.29,103 153.72,103 153.95,103.23 153.95,103.23 153.96,103.25 153.96,105.95 153.97,105.96 154.2,106.2 154.59,106.2 154.75,106.36 154.75,118.76 v1(154.19,119.33) 154.75,119.89 154.75,122.41 148.84,128.33 145,128.33 142.38,130.94 142.38,137.64 146.43,141.69 146.43,146.18 150.11,149.85 151.52,149.85 v1(151.89,149.48) ; 153.16,102.87 153.04,103 148.59,103 148.08,103.51 148.08,104.27 147.76,104.58 147,104.58 146.81,104.78 146.81,104.78 146.77,104.83 146.77,104.89 146.76,104.9 146.76,105.27 146.63,105.4 144.35,105.4 v1(143.96,105.79) ; 153.16,102.87 153.16,93.64 153.4,93.4 155.56,93.4 v1(155.96,93.79) ; v1(148.34,47.24) 152.69,47.24 156.06,43.88 170.56,43.88 171.58,44.89 171.58,58.67 176.09,63.18 v1(176.09,65.34)
  BOTTOM w0.132: TP28.1 151.89,148.34 v1(151.89,149.48) 151.89,150.75 151.26,151.38 R743.2 ; R427.1 v1(154.19,119.33)
SOC_POWER_MON_PORZ: length 13.1
  TOP w0.132: U49.4 114.31,54.24 114.35,54.28 R289.2 115.48,54.95 115.82,55.3 115.82,56.13 115.24,56.72 110.25,56.72 108.34,54.81 U50.1
SOC_SAFETY_ERRORZ: length 159
  TOP w0.132: J16.10 v1(56.43,62.87) ; U34.E20 v1(155.96,92.99)
  L05_SIG2 w0.084: TP57.1 120.09,76.1 122.38,73.8 151.25,73.8 151.74,74.3 151.74,76.58 150.93,77.39 145.14,77.39 144.86,77.67 144.86,78.82 145.95,79.91 145.95,94.01 146.13,94.19 152.16,94.19 152.32,94.03 152.32,93.67 152.64,93.36 152.91,93.36 153.12,93.14 153.12,92.87 153.41,92.59 155.46,92.59 155.86,92.99 v1(155.96,92.99) ; v1(111.84,72.16) 111.56,72.16 111.2,71.81 110.46,71.81 108.84,70.18 83.64,70.18 78.99,74.83 52.6,74.83 51.49,73.71 51.49,71.09 56.43,66.15 v1(56.43,62.87)
  L12_SIG4 w0.084: v1(111.84,72.16) 112.14,72.47 113.56,72.47 TP57.1
SOC_SERDES_REFCLK0_N: length 53.7
  TOP w0.107: v1(139.44,150.58) 139.09,150.23 139.09,149.4 139.34,149.15 J5.24 ; U34.AG5 v1(137.56,105.79)
  L12_SIG4 w0.076: v1(137.56,105.79) 137.56,105.63 137.46,105.54 137.27,105.54 133.5,109.31 133.5,112.88 135.46,114.83 135.46,131.24 139.61,135.39 139.61,143.53 138.88,144.25 138.88,150.37 139.1,150.58 v1(139.44,150.58)
SOC_SERDES_REFCLK0_P: length 53.7
  TOP w0.107: U34.AG6 v1(137.56,104.99) ; v1(138.43,150.58) 138.8,150.22 138.8,149.41 138.54,149.15 J5.25
  L12_SIG4 w0.076: v1(138.43,150.58) 138.61,150.41 138.61,144.13 139.33,143.41 139.33,135.51 135.18,131.36 135.18,114.95 133.22,112.99 133.22,109.19 137.16,105.26 137.29,105.26 v1(137.56,104.99)
SOC_SERDES_REFCLK1_N: length 47.9
  TOP w0.107: J5.55 138.54,144.77 138.27,144.51 138.27,143.55 v1(138.66,143.16) ; U34.AH6 v1(136.76,104.99)
  L12_SIG4 w0.076: v1(136.76,104.99) 136.5,104.73 135.97,104.73 131.53,109.17 131.53,114.48 132.11,115.05 132.11,129.8 138.12,135.82 138.12,143.04 138.32,143.24 138.57,143.24 v1(138.66,143.16)
SOC_SERDES_REFCLK1_P: length 47.9
  TOP w0.107: U34.AH7 v1(136.76,104.19) ; v1(137.62,143.16) 137.98,143.52 137.98,144.54 137.74,144.77 J5.56
  L12_SIG4 w0.076: v1(136.76,104.19) 136.49,104.46 135.85,104.46 131.26,109.05 131.26,114.59 131.83,115.16 131.83,129.91 137.85,135.93 137.85,142.93 v1(137.62,143.16)
SOC_SPI0_CLK: length 131.3
  TOP w0.132: U24.B2 102.3,112.52 v1(104.3,112.52) R136.1 ; J16.20 v1(53.93,62.87)
  L10_SIG3 w0.084: v1(104.3,112.52) 103.16,111.38 98.74,111.38 79.24,91.87 56.95,91.87 53.38,88.3 53.38,81.5 55.02,79.85 55.02,65.31 53.93,64.22 v1(53.93,62.87)
  BOTTOM w0.132: v1(104.3,112.52) 103.45,112.52 101.19,110.26 101.19,106.15 101.87,105.47 108.69,105.47 113.52,100.65 119.93,100.65 121.73,98.85 121.73,93.78 122.54,92.96 R491.1
SOC_SPI0_CLK_R: length 16.4
  TOP w0.132: U34.AH13 v1(136.76,99.39)
  L10_SIG3 w0.084: v1(136.76,99.39) 135.46,99.39 134.16,98.09 132.54,98.09 130.32,95.87 127.29,95.87 126.24,94.82 126.24,94.02 125.19,92.96 v1(124.73,92.96)
  BOTTOM w0.132: R491.2 v1(124.73,92.96)
SOC_SPI0_CS0: length 44.4
  TOP w0.132: U34.AG13 v1(137.56,98.59) ; U24.C2 102.28,113.54 v1(104.3,113.54) R133.1
  L05_SIG2 w0.084: v1(104.3,113.54) 105.35,112.49 105.35,111.31 112.27,104.39 116.4,104.39 118.53,102.26 119.71,102.26 121.4,100.57 121.4,100.34 122.17,99.57 124.79,99.57 125.38,98.98 137.16,98.98 v1(137.56,98.59)
SOC_SPI0_CS1: length 113.8
  TOP w0.132: J16.24 v1(52.93,62.87) ; U34.AF13 v1(138.36,99.39)
  L10_SIG3 w0.084: v1(52.93,62.87) 53.34,62.46 56.62,62.46 57.61,63.45 69.1,63.45 85.39,79.73 104.5,79.73 111.38,86.61 111.38,99.59 v1(113.26,101.47)
  L12_SIG4 w0.084: v1(138.36,99.39) 137.96,99.78 137.96,100.35 137.73,100.58 136.46,100.58 135.04,102.01 126.67,102.01 125.35,100.69 114.04,100.69 v1(113.26,101.47)
SOC_SPI0_D0: length 144.7
  TOP w0.132: U24.D3 101.3,115.57 v1(104.3,115.57) R123.1 ; J16.26 52.43,62.45 v1(51.93,61.95) ; U34.AE13 v1(139.16,99.39)
  L05_SIG2 w0.084: v1(139.16,99.39) 138.91,99.39 138.52,99.78 130.53,99.78 130.3,100.01 123.89,100.01 123.25,100.65 122.36,100.65 118.11,104.9 112.52,104.9 105.85,111.57 105.85,114.02 v1(104.3,115.57)
  L10_SIG3 w0.084: v1(51.93,61.95) 52.39,62.41 52.39,63.31 54.64,65.56 54.64,79.6 52.33,81.91 52.33,88.15 53.44,89.25 53.44,90.71 54.9,92.18 79.11,92.18 98.62,111.68 101.7,111.68 104.11,114.1 104.49,114.1 104.76,114.36 104.76,115.11 v1(104.3,115.57)
