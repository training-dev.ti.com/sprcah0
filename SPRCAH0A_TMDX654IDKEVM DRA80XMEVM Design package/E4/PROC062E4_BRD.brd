# Allegro board PROC062E4_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N23956742: length 5.8
  BOTTOM w0.356: 139.07,170.18 U130.2
  BOTTOM w0.762: L5.1 139.07,170.18
N23956744: length 5.7
  BOTTOM w0.356: 143.19,170.18 U130.10
  BOTTOM w0.762: L13.1 143.19,170.18
N23956762: length 2.1
  TOP w0.132: v1(139.62,168.13) 139.62,167.65 139.76,167.51 R792.2
  BOTTOM w0.132: v1(139.62,168.13) 140.1,168.6 U130.16
N23956795: length 2
  BOTTOM w0.132: R341.1 139.59,167.36 140.12,167.89 140.37,167.89 140.6,168.12 U130.15
N24018720: length 2.3
  TOP w0.132: R791.2 126.59,171.17 126.42,171.34 v1(126.42,172.04)
  BOTTOM w0.132: U61.A3 126.96,172.57 v1(126.42,172.04)
N24136473: length 3.4
  TOP w0.132: v1(117.22,167.64) R794.1
  BOTTOM w0.132: U64.13 116.45,166.48 116.71,166.75 116.71,167.13 v1(117.22,167.64)
N152432201: length 2.1
  TOP w0.132: R332.2 98.67,13.65 98.93,13.39 LD19.2
N182775171: length 1
  TOP w0.132: C210.1 95.49,78.13 R222.2
N184366740: length 3.3
  TOP w0.132: v1(73.99,107.99) 73.79,108.19 LD16.1
  BOTTOM w0.132: v1(73.99,107.99) 72.31,107.99 Q10.3
N194468551: length 1.8
  TOP w0.132: LD4.2 R2.2
N197540311: length 2
  TOP w0.132: LD2.2 R1.2
N197540831: length 2
  TOP w0.132: LD3.2 R3.2

## Copper pours and planes (outline as drawn)
DGND on TOP (solid shape): 39.87,112.6 34.3,112.6 34.3,118.18 39.87,118.18
DGND on TOP (solid shape): 54.6,99.45 49.03,99.45 49.03,105.02 54.6,105.02
DGND on TOP (solid shape): 80.98,140.92 80.98,140.48 78.88,140.48 78.88,141.11 80.79,141.11
DGND on TOP (solid shape): 145.37,149.24 145.18,149.24 145.18,147.01 144.78,147.01 144.78,149.44 145.37,149.44
DGND on TOP (solid shape): 65.84,97.5 66.68,97.5 66.68,96.58 65.84,96.58 65.78,96.56 65.39,96.95 65.39,98.58 65.46,98.64 65.84,98.64
DGND on TOP (solid shape): 135.61,149.43 136.03,149.43 136.03,149.24 135.58,149.24 135.58,147.01 135.1,147.01 135.1,149.24 134.91,149.24 134.91,149.81 135.39,150.29 135.61,150.29
DGND on TOP (solid shape): 46.15,102.24 43.8,102.24 39.48,97.92 39.45,97.92 39.36,97.98 39.38,98.09 44.01,102.73 46.15,102.73
DGND on TOP (solid shape): 113.36,115.82 112.24,115.82 112.24,115.69 112.18,115.6 112.07,115.62 112.04,115.65 112.04,116.34 112.64,116.94 112.64,118.62 113.36,118.62
DGND on TOP (solid shape): 81.34,144.2 80.5,144.2 80.5,144.07 80.38,144.07 80.28,144.06 80.18,144.02 80.09,144.03 80.04,144.11 80.04,144.67 80.38,145 81.34,145
DGND on TOP (solid shape): 103.65,8.59 103.65,8.18 103.56,8.18 103.56,7.41 103.06,7.41 103.06,6.62 103.01,6.6 102.91,6.6 102.86,6.69 102.86,8.03 103.53,8.7
DGND on TOP (solid shape): 79.3,70.42 79.33,70.34 79.28,70.26 79.23,70.21 79.18,70.15 77.95,68.93 58.99,68.93 58.99,71.84 59.01,71.84 59.01,72.78 58.99,72.78 58.99,74.48 75.23,74.48
DGND on TOP (solid shape): 148.51,150.2 148.57,150.1 148.57,149.24 148.38,149.24 148.38,147.01 147.9,147.01 147.9,149.24 147.71,149.24 147.71,149.5 148.34,150.13 148.37,150.16 148.4,150.18
DGND on TOP (solid shape): 31.41,113.89 30.19,113.89 29.54,113.23 29.54,113.17 29.46,113.17 29.45,113.19 29.41,113.21 29.37,113.2 29.32,113.14 29.29,113.14 29.25,113.17 29.26,113.23 30.41,114.38 31.41,114.38
DGND on TOP (solid shape): 39.23,121.77 39.23,121.06 39.17,121.04 39.14,121.06 38.86,121.06 38.86,121.11 37.92,121.11 37.92,120.75 37.88,120.71 37.81,120.68 37.73,120.72 37.71,120.75 37.4,121.06 37.15,121.06 37.15,121.11 36.58,121.11 36.58,121.34 37.26,122.02 37.26,122.48 38.52,122.48
DGND on TOP (solid shape): 92.53,66.39 92.53,63.85 90.58,61.9 90.34,61.9 90.24,61.97 90.26,62.08 90.29,62.1 90.29,62.85 89.86,63.28 89.89,63.34 89.89,65.55 89.77,65.55 89.77,65.71 89.96,65.71 89.96,67.64 89.83,67.64 89.83,67.79 89.86,67.86 89.94,67.89 91.03,67.89
DGND on TOP (solid shape): 142.21,116.66 142.33,116.66 142.4,116.63 142.43,116.57 142.64,116.26 143,116.27 143.1,116.27 143.15,116.18 143.15,114.39 142.04,114.39 142.04,114.55 141.02,114.55 141.02,115.39 140.83,115.39 140.83,117.07 141.32,117.55
DGND on TOP (solid shape): 31.42,115.39 29.99,115.39 28.74,114.14 27.86,114.14 27.77,114.2 27.78,114.31 28.03,115.01 27.77,115.72 27.76,115.82 27.85,115.88 31.42,115.88
DGND on TOP (solid shape): 41.16,121.06 41.03,120.93 40.98,120.92 40.94,120.97 40.94,121.03 40.23,121.03 40.23,121.57 40.28,121.65 40.37,121.67 40.74,121.74 40.86,122.11 40.86,122.12 40.86,122.32 40.88,122.35 40.88,122.48 41.16,122.48
DGND on TOP (solid shape): 52.84,108.75 53.3,108.29 53.9,108.29 53.95,108.24 53.95,107.9 53.62,107.9 53.62,107.95 52.68,107.95 52.68,107.6 52.64,107.56 52.56,107.53 52.49,107.57 52.46,107.6 52.16,107.9 51.9,107.9 51.9,107.95 51.36,107.95 51.36,108.37 51.57,108.58 51.58,108.58 51.75,108.85 51.66,109.16 51.64,109.27 51.73,109.33 52.84,109.33
DGND on TOP (solid shape): 46.14,103.74 43.6,103.74 38.64,98.78 34.54,98.78 34.44,98.85 34.48,98.97 35.26,100.49 34.52,102.05 34.49,102.16 34.59,102.23 34.88,102.23 35.19,101.93 41.52,101.93 43.81,104.21 46.14,104.21
DGND on TOP (solid shape): 54.78,111.68 54.86,111.64 54.88,111.55 54.86,111.46 54.87,111.38 54.85,111.29 54.77,111.26 54.69,111.26 54.69,110.42 52.76,110.42 52.76,111.03 52.81,111.12 52.91,111.12 53.34,111.14 53.48,111.55 53.49,111.64 53.57,111.68
DGND on TOP (solid shape): 118.12,156.83 118.12,156.31 118.58,155.85 118.27,155.54 118.27,152.9 117.19,151.82 115.61,151.82 115.52,151.88 115.54,151.99 116.42,152.87 116.93,152.87 116.93,154.81 116.74,154.81 116.74,154.96 117.93,154.96 117.93,156.06 117.88,156.11 117.87,156.17 117.84,156.39 117.69,156.55 117.2,157.04 117.06,157.04 116.99,157.07 116.96,157.15 116.9,157.35 116.74,157.49 116.71,157.5 116.71,157.61 117.34,157.61
DGND on TOP (solid shape): 167.23,91.6 167.23,91.2 167.18,91.12 167.08,91.12 166.52,90.78 167.08,90.44 167.18,90.44 167.23,90.35 167.23,81.44 167.17,81.35 167.06,81.37 166.06,82.37 166.06,89.1 164.21,90.95 164.17,90.95 164.17,91.69 165.2,91.69 165.2,90.94 166.29,90.94 166.29,92.03 166.81,92.03
DGND on TOP (solid shape): 188.23,104.97 188.34,104.99 188.4,104.9 188.4,102.87 187.84,102.87 187.84,103.25 187.88,103.25 187.88,104.22 186.94,104.22 186.94,104.16 186.8,104.16 186.51,103.87 186.42,103.38 186.86,103.14 186.94,103.11 186.98,103.04 186.98,102.87 185.05,102.87 185.05,102.97 185.08,103.04 185.15,103.07 185.55,103.34 185.45,103.81 185.1,104.16 185.02,104.16 185.02,104.22 184.08,104.22 184.08,103.25 184.12,103.25 184.12,103.05 184.19,102.98 184.19,102.87 182.38,102.87 182.29,102.92 182.29,103.03 182.29,103.45 182.47,103.45 182.47,104.62 187.88,104.62
DGND on TOP (solid shape): 174.66,54.19 174.77,54.21 174.83,54.11 174.83,53.8 175.61,53.8 175.61,53.52 175.63,53.52 175.63,53.42 175.58,53.42 175.58,52.48 174.63,52.48 174.63,52.63 174.19,53.06 173.76,52.63 173.76,51.97 174.41,51.32 174.41,50.98 175.03,50.98 175.12,50.93 175.15,50.42 175.51,50.22 175.56,50.22 175.61,50.18 175.6,50.13 175.51,50.04 175.51,46.58 175.83,46.26 175.86,46.19 175.83,46.12 175.73,45.96 175.72,45.78 175.7,45.7 175.62,45.66 175.21,45.66 173.09,47.78 173.09,52.62
DGND on TOP (solid shape): 153.85,85.82 153.81,85.81 153.47,85.04 154.29,84.89 154.36,84.91 154.43,84.89 155.25,85.04 154.9,85.81 154.86,85.82 154.86,86.21 157.62,86.21 157.71,86.14 157.68,86.03 157.34,85.42 157.52,84.74 157.53,84.63 157.44,84.58 153.48,84.58 152.46,85.6 152.46,86.21 153.85,86.21
DGND on TOP (solid shape): 137.26,157.56 139.47,157.56 139.47,157.61 142.06,157.61 142.15,157.55 142.14,157.45 142.07,157.3 142.07,157.14 142.07,157.13 142.07,156.38 142.74,155.72 142.86,155.72 142.86,155.4 142.82,155.32 142.73,155.31 142.27,155.1 142.42,154.62 142.48,154.56 142.17,154.25 142.1,153.65 142.69,153.72 142.74,153.77 142.86,153.77 142.86,153.01 144.54,153.01 144.75,152.79 145,152.79 145.08,152.75 145.1,152.67 145.09,152.58 145.11,152.49 145.09,152.4 145.01,152.36 143.1,152.36 142.68,151.95 142.68,147.01 142.3,147.01 142.3,149.24 142.11,149.24 142.11,149.35 141.71,149.76 141.71,154.7 141.72,154.73 141.75,154.75 142.08,155.28 141.47,155.41 141.44,155.37 140.35,156.46 139.47,156.46 139.47,156.57 137.35,156.57 137.35,157.07 136.4,157.07 136.4,157.25 136.76,157.61 137.26,157.61
DGND on TOP (solid shape): outline of 152 points within 158.39,81.37 162.31,86.93
DGND on TOP (solid shape): 122.16,101.48 122.25,101.43 122.24,101.32 122.33,100.78 122.86,100.89 122.9,100.91 122.94,100.9 123.01,100.83 122.82,100.64 122.74,100.52 122.71,100.38 122.71,99.85 123.01,99.55 122.8,99.34 122.18,99.17 122.6,98.68 122.68,98.66 122.71,98.58 122.71,98.57 123.01,98.27 122.96,98.22 122.91,98.2 122.88,98.23 122.2,98.21 122.6,97.67 122.68,97.64 122.71,97.57 122.71,97.29 123.01,96.99 122.82,96.8 122.74,96.68 122.71,96.54 122.71,95.47 122.68,95.4 122.6,95.37 122.23,95.22 122.2,94.83 122.21,94.81 122.21,94.75 122.12,94.75 121.98,94.88 121.98,95.85 121.68,96.15 121.98,96.45 121.98,97.13 121.68,97.43 121.98,97.73 121.98,100.43 121.4,101.02 121.25,101.02 121.21,101.05 121.22,101.1 121.26,101.14 121.26,101.48
DGND on TOP (solid shape): outline of 206 points within 112.44,33.02 127.65,47.89
DGND on TOP (solid shape): outline of 203 points within 24.16,96.1 32.19,102.23
DGND on TOP (solid shape): outline of 341 points within 129.55,107.09 150.25,146.92
DGND on TOP (solid shape): outline of 416 points within 147.36,40.98 159.11,45.4
DGND on TOP (solid shape): outline of 430 points within 127.4,103.57 147.9,146.92
DGND on TOP (solid shape): outline of 469 points within 123.93,102.3 142.3,146.92
DGND on TOP (solid shape): outline of 1353 points within 141.3,72.7 161.29,86.21
DGND on TOP (solid shape): outline of 72086 points within 7.51,0.52 209.66,177.28
DGND on BOTTOM (solid shape): 54.6,81.98 49.03,81.98 49.03,87.56 54.6,87.56
DGND on BOTTOM (solid shape): 81.76,15.53 79.28,15.53 79.28,18 81.76,18
DGND on BOTTOM (solid shape): 105.48,134.85 100.92,134.85 100.92,139.4 105.48,139.4
DGND on BOTTOM (solid shape): 144.87,49.28 141.32,49.28 141.32,52.83 144.87,52.83
DGND on BOTTOM (solid shape): 115.13,166.03 115.19,166.03 115.19,166.01 116.4,166.01 116.4,165.44 115.13,165.44 115.13,165.04 114.11,165.04 114.11,164.97 113.6,164.97 113.6,166.5 115.13,166.5
DGND on BOTTOM (solid shape): 179.35,11.67 179.29,11.57 179.18,11.59 178.18,12.59 178.18,14.58 179.35,14.58
DGND on BOTTOM (solid shape): 181.23,48.33 181.29,48.42 181.4,48.4 182.4,47.41 182.4,45.42 181.23,45.42
DGND on BOTTOM (solid shape): 183.88,46.85 184.06,46.85 184.06,46.8 185.04,46.8 185.04,44.79 184.99,44.74 184.94,44.73 184.91,44.78 184.91,44.98 183.8,46.09 183.8,46.84 183.86,46.87
DGND on BOTTOM (solid shape): 18.58,140.85 19.23,140.85 19.23,140.28 19.28,140.28 19.28,140.17 19.3,140.15 19.31,140.1 19.26,140.06 17.71,140.06 17.71,140.18 17.66,140.18 17.66,141.27 18.16,141.27
DGND on BOTTOM (solid shape): 190.85,73.62 190.91,73.71 191.02,73.69 191.97,72.74 191.97,65.29 194.86,62.4 194.82,62.36 194.78,62.33 190.85,66.27
DGND on BOTTOM (solid shape): 121.49,9.51 122.48,8.52 122.48,8.13 121.33,8.13 121.25,8.17 121.23,8.24 121.23,8.29 121.22,8.35 121.22,8.7 121.21,8.7 121.21,9.83 121.49,9.83
DGND on BOTTOM (solid shape): 108.02,98.33 108.13,98.28 108.24,98.26 108.61,98.26 108.61,97.94 108.51,97.94 108.37,97.91 108.25,97.83 108.12,97.7 108.06,97.63 108.03,97.54 108.01,97.5 107.93,97.5 107.93,97.51 107.18,97.51 107.18,97.93 107.63,97.93
DGND on BOTTOM (solid shape): 130.3,101.52 130.25,101.52 130.25,100.58 131.22,100.58 131.22,101.3 131.36,101.43 131.36,101.64 131.69,101.64 131.69,99.98 131.63,99.89 131.51,99.91 131.45,99.97 130.19,99.97 130.04,99.82 129.29,99.82 129.29,101.54 130.11,101.54 130.11,101.64 130.3,101.64
DGND on BOTTOM (solid shape): 26.54,158.94 26.62,158.9 26.64,158.82 26.64,158.77 26.64,158.64 26.51,158.64 26.51,157.8 25.28,157.8 25.28,158.64 24.96,158.64 24.96,158.76 24.96,158.82 24.98,158.9 25.06,158.94
DGND on BOTTOM (solid shape): 143.49,94.23 144.31,94.23 144.31,93.35 143.86,93.35 143.48,93.72 143.48,93.75 143.37,94.04 143.08,94.11 142.99,94.13 142.95,94.21 142.95,94.91 143.49,94.91
DGND on BOTTOM (solid shape): 164.83,86.42 166.77,86.42 166.77,86.52 167.93,86.52 167.93,86.44 169.13,86.44 169.13,86.47 169.16,86.51 169.21,86.5 169.23,86.49 169.23,85.24 165.23,85.24 164.04,86.43 164.01,86.54 164.11,86.6 164.83,86.6
DGND on BOTTOM (solid shape): 159.48,17.02 159.52,16.94 159.52,14.58 159.58,14.51 159.61,14.4 159.51,14.34 159.23,14.34 159.02,14.55 159.02,16.96 159.08,17.03 159.2,17.03 159.3,17.02 159.39,17.03
DGND on BOTTOM (solid shape): 131.24,111.05 132.04,111.05 135.55,107.54 135.57,107.43 135.48,107.37 134.96,107.37 133.06,109.27 131.28,109.27 131.28,110.29 130.16,110.29 130.16,110.11 129.45,110.11 128.26,111.31 128.23,111.42 128.33,111.48 130.3,111.48 130.3,111.58 130.71,111.58
DGND on BOTTOM (solid shape): 146.67,19.34 146.68,19.29 146.64,19.25 146.57,19.25 146.57,19.14 146.49,19.14 146.05,18.7 146.05,18.36 145.52,18.36 145.52,18.31 145.26,18.31 145.07,18.12 144.02,18.12 144.02,18.89 143.97,18.93 143.96,18.99 143.95,19.05 143.95,19.1 143.95,19.32 144.96,19.32 144.96,19.44 145.47,19.44 145.66,19.63 146.38,19.63
DGND on BOTTOM (solid shape): 201.36,59.27 201.42,59.36 201.54,59.34 202,58.87 202,48.05 201.79,47.84 201.61,47.84 201.61,46.9 201.74,46.9 201.74,46.8 202,46.54 202,45.12 206.92,40.2 206.92,38.89 206.86,38.8 206.75,38.82 201.36,44.2 201.36,46.94 201.49,46.94 201.49,47.87 201.36,47.87
DGND on BOTTOM (solid shape): 149.72,100.62 149.69,100.54 149.6,100.52 149.28,100.37 149.28,100.01 149.29,99.9 149.2,99.85 148.49,99.85 148.49,100.65 149.28,100.65 149.28,101.32 149.72,101.32
DGND on BOTTOM (solid shape): 139.62,129.25 139.62,128.11 140.2,128.11 140.3,128.05 140.28,127.93 139.84,127.5 138.66,127.5 138.42,127.26 138.34,127.14 138.31,126.99 138.31,126.58 138.65,126.25 138.65,126.23 138.31,125.89 138.31,122.68 137.68,122.68 137.4,122.96 137.4,126.62 139.34,128.55 139.34,129.15 139.37,129.23 139.45,129.25
DGND on BOTTOM (solid shape): 174.84,96.7 174.84,92.53 174.65,92.53 174.65,92.36 174.52,92.36 174.52,92.53 173.41,92.53 173.41,91.55 173.12,91.55 173.01,91.44 172.9,91.42 172.83,91.51 172.83,95.79 172.48,96.14 171.13,96.14 170.99,96 170.78,96 170.78,96.88 170.73,96.88 170.73,97.06 170.48,97.3 170.46,97.41 170.55,97.47 172.59,97.47 172.59,97.75 173.78,97.75
DGND on BOTTOM (solid shape): 142.51,95.85 142.55,95.77 142.55,95.08 141.99,95.08 141.99,94.32 141.43,94.32 141.43,94.96 141.46,95.03 141.53,95.06 141.77,95.14 141.88,95.37 141.89,95.41 141.95,95.41 142.33,95.8 142.33,95.81 142.35,95.84 142.38,95.86 142.42,95.87
DGND on BOTTOM (solid shape): 145.07,98.23 145.17,98.23 145.17,97.19 145.9,97.19 145.9,96.79 145.17,96.79 145.1,96.82 145.08,96.91 144.95,97.26 144.58,97.27 144.47,97.27 144.42,97.35 144.42,98.32 144.4,98.32 144.4,98.91 145.07,98.91
DGND on BOTTOM (solid shape): 122.1,97.7 122.16,97.8 122.27,97.77 122.41,97.69 122.56,97.66 122.64,97.64 122.67,97.56 122.67,97.49 123.51,97.49 123.51,95.55 122.67,95.55 122.67,95.43 122.54,95.43 122.4,95.4 122.27,95.33 122.16,95.32 122.1,95.41
DGND on BOTTOM (solid shape): 52.45,79.46 52.52,79.49 52.6,79.47 52.65,79.41 52.65,79.05 53.59,79.05 53.59,79.1 53.87,79.1 53.88,79.12 53.94,79.09 53.94,78.38 53.25,77.68 51.73,77.68 51.64,77.74 51.66,77.85 51.75,78.16 51.57,78.43 51.31,78.69 51.31,79.05 51.88,79.05 51.88,79.1 52.09,79.1 52.44,79.45
DGND on BOTTOM (solid shape): 137.74,129.98 137.85,130 137.91,129.9 137.91,129.08 137.82,128.98 137.7,128.63 137.93,128.24 137.9,128.16 136.66,126.93 136.66,123.57 136.6,123.47 136.49,123.5 136.26,123.72 136.26,128.5
DGND on BOTTOM (solid shape): 46.14,84.28 44.79,84.28 44.11,83.61 41.38,83.61 39.6,81.82 30.54,81.82 30.45,81.89 30.48,82 31.08,82.86 31.16,83.9 31.21,84.01 31.33,83.99 32.92,82.41 39.74,82.41 42.1,84.77 46.14,84.77
DGND on BOTTOM (solid shape): 140.93,118.71 140.98,118.62 140.98,117.93 142.21,116.7 142.26,116.7 142.31,116.67 142.3,116.61 142.17,116.48 142.17,116.45 141.99,116.45 141.99,115.33 142.83,115.33 142.83,114.32 143.01,114.32 143.01,114.1 142.94,114.01 142.83,114.03 140.43,116.43 140.43,118.58 140.47,118.66 140.55,118.68 140.7,118.67 140.83,118.71
DGND on BOTTOM (solid shape): 166.67,8.21 167.41,7.47 167.41,7.46 168.2,6.67 172.11,6.67 172.21,6.6 172.18,6.49 167.9,2.21 167.85,2.21 167.8,2.24 167.82,2.29 168.45,2.93 168.45,3.94 168.42,4.1 168.33,4.24 167.96,4.61 167.85,4.61 167.85,4.66 166.92,4.66 166.92,4.61 166.66,4.61 166.66,5 164.06,5 164.06,6.72 164.41,7.07 164.41,7.11 165.51,7.11 165.51,6.85 165.11,6.85 165.11,5.2 166.66,5.2 166.66,6.85 166.25,6.85 166.25,7.11 166.43,7.11 166.43,8.23 165.41,8.23 165.41,8.4 166.67,8.4
DGND on BOTTOM (solid shape): 58.7,9.41 58.81,9.43 58.87,9.34 58.87,7.43 58.62,7.18 58.51,6.84 58.51,6.79 58.41,6.79 57.98,6.36 57.54,6.79 57.44,6.79 57.44,6.84 57.33,7.18 57.08,7.43 57.08,7.78
DGND on BOTTOM (solid shape): 117.8,13.94 117.86,14.04 117.97,14.01 119.62,12.36 119.65,12.28 119.6,12.21 119.48,12.06 119.45,11.87 119.42,11.79 119.34,11.76 119.27,11.76 119.27,9.83 119.48,9.83 119.48,8.35 119.47,8.29 119.47,8.24 119.44,8.17 119.38,8.14 119.38,6.13 120.78,6.13 120.87,6.06 120.85,5.95 120.72,5.83 119.1,5.83 117.8,7.14
DGND on BOTTOM (solid shape): 146.63,94.79 146.71,94.76 146.73,94.67 146.74,94.46 146.85,94.28 147.22,93.91 147.3,93.91 147.3,93.42 147.26,93.35 147.18,93.32 147.12,93.32 146.68,93.76 146.69,93.78 146.31,94.12 146.04,93.68 146.03,93.59 145.95,93.55 145.25,93.55 145.25,94.23 146.08,94.23 146.08,94.79
DGND on BOTTOM (solid shape): 91.55,89.8 91.64,89.74 91.62,89.63 91.58,89.59 91.58,89.04 90.91,89.04 90.91,88.7 90.89,88.68 90.89,88.26 90.6,88.26 90.52,88.31 90.51,88.4 90.34,88.92 89.8,88.86 88.6,87.66 88.49,87.64 88.43,87.74 88.43,88.02 88.44,88.06 88.48,88.08 88.65,88.13 88.78,88.26 90.33,89.8
DGND on BOTTOM (solid shape): 151.35,164.64 151.38,164.69 151.43,164.68 151.6,164.51 151.71,164.51 151.71,163.5 152.83,163.5 152.83,163.67 152.92,163.67 152.93,163.64 153.59,163.53 153.32,164.15 153.29,164.16 153.28,164.2 153.28,164.6 154.29,164.6 154.29,163.2 149.86,163.2 149.86,164.23 149.89,164.3 149.97,164.33 150.18,164.36 150.33,164.51 150.42,164.59 151.35,164.59
DGND on BOTTOM (solid shape): 141,99.11 141.06,99.06 141.78,99.06 141.78,98.15 142.47,98.15 142.47,97.13 142.59,97.13 142.59,96.95 142.66,96.88 142.66,96.57 142.61,96.48 142.51,96.48 142.45,96.51 142.38,96.52 142.35,96.54 142.33,96.57 142.33,96.81 142.01,97.13 142.01,97.28 141.84,97.28 141.28,97.84 140.83,97.84 140.83,98.27 140.86,98.28 141.08,98.64 140.76,98.92 140.73,98.94 140.71,98.97 140.71,99.01 140.73,99.04 140.76,99.06 140.84,99.07 140.92,99.1
DGND on BOTTOM (solid shape): 145.99,103.06 145.99,102.15 146.69,102.15 146.77,102.1 146.78,102 146.72,101.79 146.78,101.58 146.77,101.48 146.69,101.43 145.92,101.43 145.92,100.79 145.25,100.79 145.25,101.41 145.3,101.5 145.4,101.5 145.88,101.74 145.49,102.11 145.4,102.13 145.36,102.21 145.36,103.06
DGND on BOTTOM (solid shape): 148.44,92.9 148.63,92.68 148.92,92.7 149.02,92.7 149.07,92.62 149.07,92.56 149.02,92.48 148.59,92.48 148.43,92.19 148.42,92.17 147.97,91.72 147.97,91.64 147.41,91.64 147.41,91.83 146.75,91.83 146.75,92.67 146.73,92.72 146.77,92.77 146.84,92.79 146.92,92.76 147.24,92.67 147.47,92.9 147.48,92.94 148.43,92.94
DGND on BOTTOM (solid shape): 146.84,95.65 146.9,95.75 147.01,95.72 147.04,95.69 147.3,95.69 147.3,95.58 148.33,95.58 148.41,95.54 148.43,95.46 148.56,95.12 148.92,95.1 149.02,95.1 149.07,95.02 149.07,95 149.25,95 149.34,94.93 149.32,94.82 149.24,94.7 149.23,94.55 149.2,94.47 149.13,94.44 148.49,94.44 148.49,94.89 147.46,94.89 147.46,94.9 147.23,95.01 146.98,94.98 146.88,94.99 146.84,95.08
DGND on BOTTOM (solid shape): 183.13,64.79 183.2,64.88 183.31,64.86 183.51,64.65 185.18,64.65 185.23,64.62 185.22,64.57 185.15,64.5 185.03,64.35 184.99,64.16 184.99,63.38 184.95,63.38 184.95,62.41 185.66,62.41 185.75,62.35 185.73,62.24 185.47,61.98 185.47,60.53 185.51,60.49 185.52,60.43 185.47,60.4 184.99,60.4 184.99,60.35 183.3,60.35 182.87,60.78 182.87,61.17 182.88,61.19 184.23,61.19 184.23,63.14 184.12,63.14 184.05,63.17 184.02,63.24 183.62,63.63 183.26,63.2 183.26,63.14 183.13,63.14
DGND on BOTTOM (solid shape): 43.61,87.07 43.69,87.03 43.7,86.94 43.94,86.47 44.42,86.68 44.49,86.74 44.58,86.71 45.02,86.28 46.14,86.28 46.14,85.78 43.65,85.78 43.56,85.82 43.55,85.92 43.19,86.43 42.83,85.92 42.82,85.82 42.74,85.78 41.68,85.78 39.32,83.42 33.34,83.42 32.96,83.8 32.94,83.91 33.03,83.97 38.68,83.97 41.78,87.07
DGND on BOTTOM (solid shape): 153.23,98.91 153.99,98.91 153.99,98.26 153.86,98.26 153.86,97.99 152.12,97.99 152.12,97.77 151.65,97.3 151.61,97.25 151.58,97.21 151.5,97.16 151.41,97.19 151.37,97.24 151.31,97.28 151.28,97.3 151.28,98.1 151.46,98.28 151.58,98.51 151.55,98.76 151.56,98.86 151.64,98.91 152.38,98.91 152.47,98.86 152.47,98.76 152.96,98.33 152.67,98.91 152.58,98.93 152.54,99.01 152.54,99.73 153.23,99.73
DGND on BOTTOM (solid shape): 191.92,146.89 191.99,146.98 192.1,146.96 192.38,146.68 192.38,146.3 192.34,146.22 192.26,146.2 191.64,145.67 192.26,145.14 192.34,145.12 192.38,145.04 192.38,144.1 191.22,142.95 191.15,142.92 191.07,142.96 191.05,142.99 191.02,143.01 191.01,143.19 190.95,143.36 190.95,144.22 191,144.3 191.09,144.31 191.64,144.65 191.09,145 191,145 190.95,145.09 190.95,145.54 191.92,146.52
DGND on BOTTOM (solid shape): outline of 118 points within 106.19,101.02 114.44,106.11
DGND on BOTTOM (solid shape): outline of 134 points within 136.96,163.4 145.19,169.7
DGND on BOTTOM (solid shape): 141.94,127.97 142.33,127.97 142.43,127.9 142.41,127.79 142.13,127.51 142.13,126.47 142.08,126.39 141.98,126.38 141.72,126.41 141.51,126.27 141.43,126.22 141.35,126.25 141.21,126.4 140.6,126.4 140.6,125.79 141.13,125.25 141.15,125.22 141.13,125.18 141.3,124.55 141.77,125.01 141.79,125.09 141.87,125.13 142.56,125.13 142.62,125.2 142.81,125.2 142.81,122.95 139.05,122.95 139.05,125.59 139.3,125.83 139.33,125.84 139.37,125.83 140.01,126.01 139.52,126.46 139.43,126.47 139.39,126.56 139.36,126.58 139.34,126.69 139.43,126.76 140.15,126.76 141.38,127.99 141.38,128.11 141.56,128.11 141.56,128.83 141.71,128.98 141.94,128.98
DGND on BOTTOM (solid shape): 146.84,99.65 146.9,99.75 147.01,99.72 147.14,99.6 147.3,99.6 147.3,99.48 148.34,99.48 148.34,98.91 149.07,98.91 149.15,98.86 149.16,98.76 149.13,98.51 149.25,98.28 149.33,98.2 149.33,97.23 149.3,96.78 149.74,96.72 149.84,96.72 149.9,96.63 149.9,95.96 149.07,95.96 149.07,95.76 149.02,95.68 148.92,95.68 148.78,95.72 148.63,95.7 148.53,95.7 148.49,95.79 148.49,96.59 148.53,96.68 148.63,96.68 148.97,97.24 148.47,96.82 148.47,96.72 148.38,96.67 147.3,96.67 147.3,96.61 147.11,96.62 146.98,96.58 146.88,96.59 146.84,96.68 146.84,97.35 146.26,97.35 146.26,98.39 146.15,98.39 146.15,98.61 146.01,98.74 146.01,98.93 146.55,98.93 146.55,98.27 146.86,98.27 147.07,98.07 147.07,97.45 148.03,97.45 148.03,98.39 147.97,98.39 147.51,98.84 147.51,99.21 146.84,99.21
DGND on BOTTOM (solid shape): 157.33,17.66 157.42,17.62 157.43,17.53 157.79,17.02 158.15,17.53 158.16,17.62 158.24,17.66 158.42,17.66 158.51,17.6 158.49,17.49 158.27,17.27 158.27,14.24 158.92,13.6 162.43,13.6 162.55,13.48 162.57,13.37 162.47,13.31 161.93,13.31 161.93,11.22 161.88,11.18 161.83,11.13 161.76,11.1 161.69,11.12 161.49,11.24 161.26,11.26 161.18,11.28 161.15,11.36 161.15,13.31 158.93,13.31 158.93,11.25 158.89,11.24 158.78,11.2 158.68,11.12 158.61,11.09 158.54,11.12 158.38,11.22 158.2,11.26 158.16,11.28 158.15,11.31 158.15,13.31 155.93,13.31 155.93,11.34 155.89,11.26 155.8,11.24 155.46,11.23 155.19,11 155.18,10.98 155.1,10.98 155.1,11.2 155.15,11.2 155.15,13.31 154.43,13.31 154.43,16.01 154.48,16.1 154.59,16.1 155.11,16.22 154.99,16.74 154.99,16.75 154.87,16.87 154.84,16.96 154.91,17.04 155.02,17.1 155.11,17.19 155.11,17.2 155.58,17.66
DGND on BOTTOM (solid shape): 160.01,103.76 160.08,103.79 160.16,103.76 160.19,103.73 160.22,103.7 160.27,103.63 160.24,103.55 159.5,102.82 159.49,102.8 159.45,102.78 159.41,102.8 159.05,102.9 158.83,102.61 158.82,102.56 157.89,102.56 157.88,102.61 157.56,102.92 157.23,102.61 157.22,102.56 157.09,102.56 157.08,102.61 156.76,102.92 156.43,102.61 156.42,102.56 156.29,102.56 156.28,102.61 156.19,102.82 155.98,102.92 155.94,102.94 155.93,102.97 155.93,103.01 155.94,103.04 155.98,103.06 156.19,103.16 156.28,103.37 156.29,103.42 156.42,103.42 156.43,103.37 156.76,103.06 157.08,103.37 157.09,103.42 157.22,103.42 157.23,103.37 157.56,103.06 157.88,103.37 157.89,103.42 158.02,103.42 158.03,103.37 158.36,103.06 158.68,103.37 158.69,103.42 158.82,103.42 158.83,103.37 159.15,103.06 159.48,103.36 159.5,103.4 159.53,103.41 159.66,103.44 159.77,103.52
DGND on BOTTOM (solid shape): outline of 229 points within 160.06,7.67 173.04,17.93
DGND on BOTTOM (solid shape): 174.65,90.6 174.71,90.6 174.71,88.8 173.62,87.71 173.62,80.02 172.53,78.94 172.39,78.63 172.47,78.3 172.48,78.2 172.39,78.15 171.61,78.15 171.52,78.21 171.55,78.32 171.5,79.57 170.28,79.3 170.05,79.3 169.73,79.62 169.7,79.71 169.76,79.78 170.16,80.18 170.2,80.74 170.19,80.77 170.52,81.1 171.09,80.53 171.3,80.53 172.83,80.81 171.4,81.42 171.33,81.39 171.25,81.42 171.2,81.47 171.2,82.63 171.26,82.72 171.38,82.69 172.79,82.93 171.8,83.97 171.77,83.96 170.82,84.91 170.8,85.02 170.9,85.08 171.06,85.08 171.06,86.99 171.35,87.28 172.76,87.28 172.76,89.31 172.53,89.31 172.44,89.37 172.46,89.49 172.83,89.86 172.83,90.25 172.86,90.32 172.93,90.35 173.07,90.38 173.19,90.47 173.34,90.63 173.41,90.6 174.52,90.6 174.52,91.62 174.65,91.62
DGND on BOTTOM (solid shape): 154.74,101.21 154.82,101.17 154.84,101.08 154.85,100.87 154.98,100.71 155.03,100.63 155,100.55 154.9,100.45 154.9,99.93 155.41,99.93 155.52,100.03 155.6,100.06 155.67,100.02 155.79,99.91 155.93,99.86 155.97,99.84 155.98,99.81 155.98,99.77 155.97,99.74 155.93,99.72 155.63,99.39 155.93,99.06 155.97,99.04 155.98,99.01 155.98,98.97 155.97,98.94 155.93,98.92 155.64,98.7 155.73,98.35 155.75,98.33 155.75,98.26 155.69,98.26 155.69,97.32 155.75,97.32 155.75,97.25 155.7,97.2 155.67,97.16 155.6,97.12 155.52,97.15 155.41,97.25 155.21,97.35 154.98,97.31 154.88,97.31 154.83,97.4 154.83,98.15 154.95,98.15 154.95,98.97 154.99,99.05 155.08,99.07 155.36,99.65 154.86,99.23 154.86,99.13 154.77,99.09 154.19,99.09 154.19,99.76 154.23,99.84 154.31,99.86 154.53,100.47 154.08,100.01 154.09,99.9 154,99.85 153.3,99.85 153.3,100.65 154.01,100.65 154.01,101.21
DGND on BOTTOM (solid shape): outline of 265 points within 88,89.68 100.57,97.6
DGND on BOTTOM (solid shape): outline of 253 points within 150.01,90.83 152.96,94.23
DGND on BOTTOM (solid shape): outline of 325 points within 89.94,131.57 100.06,142.62
DGND on BOTTOM (solid shape): outline of 108 points within 143.41,116.54 153.45,137.81
DGND on BOTTOM (solid shape): outline of 547 points within 168.38,45.42 183.79,65.03
DGND on BOTTOM (solid shape): outline of 583 points within 152.33,85.37 158.09,91.62
DGND on BOTTOM (solid shape): outline of 604 points within 137.54,108.15 142.78,119.98
DGND on BOTTOM (solid shape): outline of 611 points within 154.84,96.96 160.54,101.83
DGND on BOTTOM (solid shape): outline of 665 points within 131.74,98.28 142.11,103.66
DGND on BOTTOM (solid shape): outline of 1293 points within 141.72,104.03 147.65,121.68
DGND on BOTTOM (solid shape): outline of 1318 points within 148.39,103.76 159.08,114.93
DGND on BOTTOM (solid shape): outline of 77641 points within 7.51,0.52 209.66,177.28
DGND on L03_SIG1 (solid shape): 161.4,35.08 161.71,34.78 161.71,20.65 159.56,18.51 159.2,18.51 159.1,18.57 159.13,18.68 160.88,20.44 160.88,34.36 160.89,34.39 161.29,34.78 161.29,35.1 161.35,35.1
DGND on L05_SIG2 (solid shape): 176.39,100.81 177.12,100.81 178.38,99.55 178.38,98.94 177.46,98.94 177.46,99.35 173.01,103.81 172.99,103.92 173.08,103.98 173.21,103.98
DGND on L05_SIG2 (solid shape): 66.35,98.17 66.4,98.14 66.39,98.08 66.35,98.05 66.35,97.44 64.07,97.44 63.98,97.5 64,97.61 64.56,98.17
DGND on L05_SIG2 (solid shape): 46.21,134.25 46.23,134.14 46.14,134.08 29.38,134.08 29.05,134.41 29.03,134.52 29.12,134.58 45.88,134.58
DGND on L05_SIG2 (solid shape): 93.35,89.61 93.37,89.5 93.28,89.44 86.12,89.44 85.9,89.66 85.88,89.77 85.97,89.84 93.13,89.84
DGND on L05_SIG2 (solid shape): 201.74,147.93 201.74,147.69 201.68,147.6 201.56,147.62 196.24,152.95 196.22,153.06 196.31,153.12 196.55,153.12
DGND on L05_SIG2 (solid shape): 109.04,97.62 109.06,97.51 108.97,97.44 104.32,97.44 104.32,97.94 104.27,97.99 104.25,98.11 104.34,98.17 108.49,98.17
DGND on L05_SIG2 (solid shape): 137.98,101.05 137.98,101.02 137.94,100.96 137.87,100.93 136.41,100.93 136.01,101.34 126.93,101.34 126.68,101.59 126.65,101.7 126.75,101.76 137.27,101.76
DGND on L05_SIG2 (solid shape): 146.2,79.67 146.32,79.7 146.38,79.6 146.38,79.19 145.34,78.15 145.28,78.12 145.23,78.12 145.2,78.16 145.2,78.67
DGND on L05_SIG2 (solid shape): 90.9,12.59 118.54,12.59 118.63,12.53 118.61,12.42 118.03,11.84 82.87,11.84 81.83,12.88 81.81,12.99 81.91,13.05 90.44,13.05
DGND on L05_SIG2 (solid shape): 135.14,57.16 135.2,57.15 135.26,57.12 135.29,57.05 135.29,56.63 130.5,51.85 129.59,51.85 129.49,51.91 129.51,52.02 134.68,57.18 135.07,57.18
DGND on L05_SIG2 (solid shape): 136.49,116.12 136.51,116.01 136.42,115.95 136.06,115.95 135.45,116.56 134.21,116.56 134.14,116.59 134.11,116.66 134.11,116.75 135.87,116.75
DGND on L05_SIG2 (solid shape): 177.07,87.65 177.14,87.63 178.01,86.76 178.01,85.2 176.97,85.2 176.65,85.53 176.65,87.42 176.68,87.49 176.75,87.52 176.88,87.55 177,87.63
DGND on L05_SIG2 (solid shape): 159.85,78.52 159.87,78.41 159.77,78.35 159.06,78.35 157.17,80.24 157.17,80.69 157.19,80.75 157.26,80.79 157.36,80.81 157.45,80.86 157.49,80.88
DGND on L05_SIG2 (solid shape): 185.06,79.98 185.17,80 185.23,79.91 185.23,78.72 179.6,78.72 179.48,78.84 179.48,79.84 179.54,79.94 179.65,79.92 180.12,79.45 184.53,79.45
DGND on L05_SIG2 (solid shape): 168.53,131.3 168.63,131.23 168.61,131.12 168.37,130.89 168.37,129.96 166.08,127.66 165.86,127.66 165.77,127.73 165.79,127.84 166.53,128.57 166.53,130.29 167.54,131.3
DGND on L05_SIG2 (solid shape): 70.65,97.89 77.84,97.89 77.84,97.63 77.86,97.61 77.88,97.5 77.79,97.44 70.09,97.44 70.09,97.9 70.09,97.97 70.07,98.03 70.08,98.12 70.17,98.17 70.37,98.17
DGND on L05_SIG2 (solid shape): 168.8,109.07 168.8,107.56 168.73,107.47 168.62,107.49 167.62,108.49 163.61,108.49 163.28,108.83 162.29,108.83 161.96,108.49 161.46,108.49 161.36,108.56 161.38,108.67 161.95,109.23 168.63,109.23
DGND on L05_SIG2 (solid shape): 105.08,93.09 105.18,92.98 105.12,92.92 105.09,92.93 105.02,92.96 104.94,92.97 104.63,92.97 104.5,92.94 104.39,92.87 104.18,92.65 103.86,92.97 100.5,92.97 100.41,93.05 100.39,93.16 100.49,93.23 104.78,93.23 104.98,93.43 105.08,93.43
DGND on L05_SIG2 (solid shape): 135.32,102.63 135.35,102.52 135.25,102.45 128.05,102.45 127.97,102.49 127.95,102.57 127.95,102.61 127.98,102.68 128.05,102.71 130.83,102.71 131.21,103.09 134.86,103.09
DGND on L05_SIG2 (solid shape): 115.03,121.33 115.14,121.35 115.2,121.25 115.23,120.8 115.43,120.4 115.44,120.29 115.34,120.23 112.63,120.23 112.05,120.81 112.26,121.03 114.72,121.03
DGND on L05_SIG2 (solid shape): 138.2,116.47 141.94,116.47 142.04,116.41 142.02,116.29 141.92,116.2 137.83,116.2 135.57,118.46 134.19,118.46 134.11,118.5 134.1,118.59 134.11,118.64 134.11,118.69 134.14,118.76 134.21,118.79 135.88,118.79
DGND on L05_SIG2 (solid shape): 13.51,92.03 13.57,91.94 13.57,88.1 13.14,87.67 13.13,87.66 13.02,87.59 12.93,87.48 12.86,87.42 12.77,87.45 12.54,87.68 12.54,91.2 13.24,91.9 13.25,91.9 13.33,91.94 13.39,92
DGND on L05_SIG2 (solid shape): 71.62,8.83 73.91,8.83 73.98,8.8 74.01,8.73 74.01,8.67 69.87,8.67 60.46,18.07 60.43,18.15 60.46,18.22 60.58,18.38 60.63,18.58 60.67,18.65 60.73,18.68 61.78,18.68
DGND on L05_SIG2 (solid shape): 147.36,81.33 147.42,81.42 147.54,81.4 147.7,81.24 147.7,80.54 150.32,77.91 150.34,77.8 150.25,77.74 148.15,77.74 148.15,77.79 148.08,78 147.91,78.14 147.9,78.15 147.36,78.68
DGND on L05_SIG2 (solid shape): 182.38,107.4 182.44,107.5 182.55,107.48 182.67,107.41 182.8,107.38 182.86,107.35 182.89,107.28 182.89,106.59 183.23,106.25 183.6,106.25 183.63,106.22 183.63,106.15 183.17,106.15 182.94,105.92 182.91,105.88 182.88,105.84 182.79,105.86 182.79,106.63 182.38,107.04
DGND on L05_SIG2 (solid shape): 83.06,15.75 83.03,15.72 82.98,15.51 83.04,15.3 83.05,15.2 82.96,15.14 78.08,15.14 77.99,15.2 78,15.3 78.02,15.33 78.04,15.38 78.46,15.81 83,15.81
DGND on L05_SIG2 (solid shape): 172.07,63.13 172.14,63.12 172.2,63.12 172.28,63.09 172.31,63.02 172.31,54.61 172.96,53.96 173.98,53.96 174.18,54.16 174.29,54.18 174.36,54.09 174.36,53.89 174.2,53.74 172.48,53.74 172.11,54.11 172.11,62.71 172.08,62.84 172.01,62.96 171.94,63.03 172.04,63.14
DGND on L05_SIG2 (solid shape): 173.25,90.47 173.3,90.38 173.3,89.29 173.59,89 173.3,88.72 173.3,81.43 173.24,81.34 173.13,81.36 172.77,81.72 172.77,90.27 172.8,90.35 172.87,90.37 173.01,90.39 173.14,90.46
DGND on L05_SIG2 (solid shape): 173.92,59.31 173.98,59.41 174.09,59.38 176.33,57.14 176.59,57.14 176.72,57.17 176.84,57.25 177.19,57.6 177.71,57.08 177.71,56.03 177.29,55.61 177.28,55.61 177.12,55.48 177.05,55.29 177.01,55.22 176.95,55.19 176.77,55.19 173.92,58.04
DGND on L05_SIG2 (solid shape): 133.55,111.13 133.66,111.15 133.72,111.05 133.82,110.52 134.12,110.06 134.14,109.95 134.05,109.89 128.28,109.89 127.38,110.78 127.36,110.89 127.45,110.96 133.38,110.96
DGND on L05_SIG2 (solid shape): 183.77,135.27 183.84,135.24 183.87,135.17 184.05,134.87 184.39,134.83 184.48,134.82 184.53,134.74 184.53,133.32 184.46,133.25 184.4,133.24 184.37,133.29 184.37,133.95 183.9,134.42 183.63,134.42 183.63,135.23 183.67,135.27
DGND on L05_SIG2 (solid shape): 183.77,121.55 183.84,121.52 183.87,121.45 184.05,121.16 184.39,121.12 184.48,121.11 184.53,121.02 184.53,119.6 184.46,119.54 184.4,119.53 184.37,119.57 184.37,120.24 183.9,120.71 183.63,120.71 183.63,121.51 183.67,121.55
DGND on L05_SIG2 (solid shape): 183.77,107.83 183.84,107.81 183.87,107.74 184.05,107.44 184.39,107.4 184.48,107.39 184.53,107.31 184.53,105.89 184.46,105.82 184.4,105.81 184.37,105.85 184.37,106.53 183.9,106.99 183.63,106.99 183.63,107.8 183.67,107.83
DGND on L05_SIG2 (solid shape): 183.77,94.12 183.84,94.09 183.87,94.02 184.05,93.72 184.39,93.69 184.48,93.68 184.53,93.59 184.53,92.17 184.47,92.12 184.42,92.11 184.38,92.15 184.38,92.79 183.9,93.27 183.63,93.27 183.63,94.09 183.65,94.12
DGND on L05_SIG2 (solid shape): 167.29,102.34 167.31,102.23 167.22,102.17 165.51,102.17 165.28,101.94 165.22,101.88 165.04,102.06 164.93,102.14 164.78,102.17 163.51,102.17 163.42,102.22 163.43,102.33 163.48,102.44 163.5,102.56 163.53,102.63 163.6,102.66 166.97,102.66
DGND on L05_SIG2 (solid shape): 169.67,91.57 169.73,91.66 169.84,91.64 171.66,89.82 171.66,88.49 170.74,88.49 170.4,88.15 170.4,86.62 170.43,86.48 170.51,86.36 170.74,86.13 171.28,86.13 171.42,86.16 171.54,86.24 171.58,86.28 171.63,86.29 171.66,86.24 171.66,84.63 171.6,84.54 171.49,84.56 169.67,86.39
DGND on L05_SIG2 (solid shape): 182.42,93.59 182.48,93.68 182.58,93.67 182.68,93.62 182.8,93.6 182.86,93.57 182.89,93.5 182.89,93.03 182.92,92.89 183,92.77 183.23,92.54 183.6,92.54 183.62,92.52 183.63,92.46 183.58,92.43 183.17,92.43 182.96,92.22 182.85,92.2 182.79,92.29 182.79,92.94 182.42,93.31
DGND on L05_SIG2 (solid shape): 182.37,134.76 182.43,134.85 182.54,134.83 182.66,134.75 182.79,134.72 182.86,134.69 182.89,134.62 182.89,134.18 182.92,134.03 183,133.91 183.23,133.68 183.6,133.68 183.62,133.66 183.63,133.61 183.58,133.58 183.17,133.58 182.96,133.37 182.85,133.35 182.79,133.44 182.79,134.09 182.37,134.51
DGND on L05_SIG2 (solid shape): 182.37,121.07 182.43,121.16 182.54,121.14 182.66,121.06 182.8,121.03 182.86,121 182.89,120.93 182.89,120.46 182.92,120.32 183,120.2 183.23,119.97 183.6,119.97 183.62,119.95 183.63,119.89 183.58,119.86 183.17,119.86 182.96,119.65 182.85,119.63 182.79,119.72 182.79,120.38 182.37,120.79
DGND on L05_SIG2 (solid shape): 174.98,55.53 175.05,55.5 176.64,53.91 177.05,53.91 177.15,53.84 177.13,53.73 175.72,52.33 174.63,52.33 174.63,52.33 174.63,52.63 174.59,52.79 174.51,52.92 174.48,53 174.51,53.07 175.05,53.61 175.05,54.6 175.05,54.6 175.03,54.95 174.73,55.13 174.65,55.2 174.67,55.31 174.76,55.4 174.84,55.44 174.9,55.49
DGND on L05_SIG2 (solid shape): 133.87,45.98 133.96,45.92 133.94,45.81 131.89,43.76 129.43,43.76 129.35,43.79 129.33,43.87 128.95,44.29 128.57,43.87 128.54,43.79 128.47,43.76 127.72,43.76 126.67,42.7 125.69,42.7 124.64,41.65 124.64,41.65 124.58,41.55 124.46,41.58 124.21,41.83 123.85,41.83 122.89,42.79 122.89,45.06 123.82,45.98
DGND on L05_SIG2 (solid shape): 152.37,95.37 152.49,95.12 152.74,95.01 152.8,94.98 152.83,94.91 152.83,94.38 152.65,94.2 152.41,94.44 152.37,94.47 152.32,94.5 152.11,94.94 151.64,94.8 151.56,94.76 151.47,94.8 151.42,94.86 151.37,94.91 151.32,94.99 151.37,95.07 151.49,95.2 151.54,95.37 151.54,95.42 152.37,95.42
DGND on L05_SIG2 (solid shape): 113.57,153.55 113.65,153.52 113.68,153.44 114.06,153.03 114.43,153.44 114.46,153.52 114.54,153.55 115.58,153.55 115.68,153.49 115.66,153.38 114.83,152.56 111.43,152.56 111.07,152.2 31.24,152.2 31.17,152.23 31.14,152.31 31.14,152.4 31.11,152.48 31.12,152.58 31.21,152.62 105.87,152.62 106.8,153.55
DGND on L05_SIG2 (solid shape): 124.28,101.38 124.37,101.33 124.38,101.24 124.73,100.71 125.08,101.24 125.09,101.33 125.17,101.38 125.9,101.38 126.64,100.64 135.72,100.64 136.13,100.24 136.37,100.24 136.37,100.13 130.68,100.13 130.45,100.36 124.03,100.36 123.4,100.99 123.02,100.99 122.95,101.02 122.92,101.1 122.91,101.17 122.89,101.24 122.9,101.33 122.99,101.38
DGND on L05_SIG2 (solid shape): 97.2,91.54 97.28,91.5 97.29,91.41 97.66,90.93 98.03,91.41 98.05,91.5 98.13,91.54 99.7,91.54 100.73,90.51 108.05,90.51 108.14,90.45 108.12,90.34 107.72,89.93 97.44,89.93 96.67,90.7 96.65,90.8 96.74,90.87 97.04,91.05 97.06,91.4 97.07,91.49 97.16,91.54
DGND on L05_SIG2 (solid shape): 153.97,91.38 154.36,91.01 154.74,91.38 154.74,91.43 155.57,91.43 155.57,91.38 155.62,91.21 155.74,91.07 155.79,90.99 155.74,90.91 155.69,90.86 155.64,90.8 155.56,90.76 155.47,90.8 155.05,90.96 154.77,90.6 154.77,90.55 153.94,90.55 153.94,90.6 153.8,90.88 153.5,90.97 153.47,90.96 153.16,91.28 153.32,91.43 153.97,91.43
DGND on L05_SIG2 (solid shape): 99.57,120.29 99.66,120.23 99.65,120.12 99.78,119.55 100.32,119.79 100.38,119.86 100.48,119.84 100.89,119.81 101.09,120.18 101.12,120.25 101.19,120.29 108.88,120.29 108.97,120.23 108.96,120.13 108.91,119.98 108.92,119.81 108.9,119.72 108.82,119.68 101.84,119.68 101.15,119 88.12,119 88.03,119.06 88.05,119.17 89.17,120.29
DGND on L05_SIG2 (solid shape): 165.72,91.86 165.72,88.45 165.66,88.36 165.55,88.38 165.12,88.81 163.49,88.81 162.81,89.5 160.99,89.5 160.92,89.53 160.89,89.6 160.88,89.64 160.86,89.67 159.98,90.55 159.77,90.55 159.65,90.57 159.53,90.62 157.94,90.62 157.93,90.66 157.87,90.8 157.77,90.91 157.72,90.99 157.77,91.07 157.89,91.21 157.94,91.38 157.94,91.43 159.39,91.43 159.42,91.41 159.46,91.39 159.74,91.29 160.03,91.37 162.45,91.37 162.52,91.34 162.55,91.27 162.93,90.9 163.31,91.27 163.34,91.34 163.41,91.37 164.37,91.37 165.29,92.29
DGND on L05_SIG2 (solid shape): 143.96,86.21 144,86.19 144.02,86.16 144.02,81.05 145.11,79.95 145.15,79.87 145.21,79.81 145.24,79.74 145.21,79.66 144.51,78.96 144.51,77.53 144.99,77.05 147.46,77.05 147.55,76.98 147.53,76.87 147.18,76.53 147.09,76.5 147.01,76.57 146.98,76.62 146.92,76.64 145.23,76.64 143.12,78.76 143.12,79.21 143.16,79.29 143.24,79.31 143.69,79.69 143.24,80.07 143.16,80.09 143.12,80.17 143.12,81.5 143.15,81.57 143.23,81.6 143.45,81.66 143.6,81.84 143.6,81.85 143.89,82.14 143.89,86.16 143.91,86.19 143.94,86.21
DGND on L05_SIG2 (solid shape): 189.44,146.63 189.52,146.59 189.56,146.55 189.56,145.13 189.51,145.04 189.41,145.04 188.83,144.72 189.41,144.39 189.51,144.39 189.56,144.3 189.56,144.11 189.36,143.91 189.33,143.92 188.9,143.77 188.91,143.32 188.93,143.25 188.89,143.18 188.85,143.14 188.81,143.13 188.78,143.14 188.61,143.25 188.42,143.29 188.4,143.29 188.3,143.38 188.3,144.15 188.63,144.48 188.63,146.07 188.9,146.34 188.92,146.34 189.17,146.41 189.36,146.58
DGND on L05_SIG2 (solid shape): 73.73,108.41 73.76,108.33 73.73,108.26 73.72,107.72 74.27,107.72 74.34,107.76 74.41,107.73 77.4,104.74 77.43,104.65 77.38,104.58 77.31,103.99 77.9,104.06 77.98,104.11 78.06,104.08 78.31,103.83 78.33,103.71 78.24,103.65 76.54,103.65 73.9,106.29 74.06,106.44 74.13,106.56 74.16,106.69 74.16,106.95 73.66,107.45 73.37,107.45 73.37,107.84 72.97,108.24 72.86,108.32 72.73,108.34 72.46,108.34 72.16,108.04 70.93,109.27 70.9,109.38 71,109.44 72.69,109.44
DGND on L05_SIG2 (solid shape): 121.15,107.12 121.22,107.09 121.25,107.02 121.43,106.71 121.78,106.68 121.79,106.68 122.24,106.68 122.25,106.69 133.55,106.69 134.4,105.84 134.42,105.73 134.33,105.67 123.03,105.67 123.02,105.67 122.49,105.32 123.02,104.97 123.03,104.97 124.96,104.97 125.04,104.93 125.05,104.84 125.07,104.56 125.27,104.36 125.28,104.35 125.68,103.96 126.13,103.96 126.22,103.91 126.22,103.81 126.18,103.68 126.19,103.53 126.17,103.45 126.09,103.41 123.08,103.41 120.64,105.85 119.74,105.85 119.64,105.91 119.67,106.02 120.77,107.12
DGND on L05_SIG2 (solid shape): 152.22,88.46 152.38,87.82 153.02,87.66 153.05,87.56 153.27,86.94 153.92,87 153.96,87.02 153.99,87 154.17,86.89 154.38,86.86 154.45,86.83 154.48,86.76 154.48,86.11 154.63,85.96 154.66,85.86 154.59,85.79 154.51,85.75 154.43,85.69 154.36,85.66 154.29,85.69 153.8,85.8 153.43,85.45 153.36,85.39 153.26,85.41 151.91,86.77 151.91,88.41 151.93,88.44 151.96,88.46 152.04,88.46 152.12,88.48
DGND on L05_SIG2 (solid shape): 133.35,115.65 133.73,115.27 134.11,115.65 134.11,115.7 135.1,115.7 135.71,115.09 136.59,115.09 136.8,114.88 136.44,114.52 134.21,114.52 134.14,114.55 134.11,114.62 133.6,114.99 133.45,114.37 133.48,114.34 133.16,114.02 133.09,113.99 133.02,114.02 132.89,114.15 132.86,114.23 132.91,114.3 133.07,114.78 132.62,115 132.53,115.02 132.49,115.1 132.49,115.18 132.53,115.26 132.95,115.35 133.1,115.65 133.1,115.7 133.35,115.7
DGND on L05_SIG2 (solid shape): 148.69,83.39 148.76,83.49 148.87,83.47 150.05,82.28 150.08,82.21 150.05,82.13 150.04,81.58 150.59,81.6 150.66,81.63 150.73,81.6 152.87,79.46 152.87,79.17 152.86,79.14 152.82,79.12 152.46,78.74 152.82,78.36 152.86,78.34 152.87,78.31 152.87,78.16 152.86,78.12 152.82,78.1 152.7,78.08 152.59,78.01 152.52,77.98 152.45,78.01 151.8,78.65 151.73,78.65 150.14,80.24 150.11,80.31 150.14,80.39 150.13,80.91 149.6,80.92 149.53,80.9 149.46,80.93 148.69,81.69
DGND on L05_SIG2 (solid shape): 67.25,107.93 67.36,107.85 67.49,107.83 68.06,107.83 68.25,108.01 68.26,108.02 68.3,108.04 68.34,108.02 68.43,107.93 68.54,107.85 68.68,107.83 68.97,107.83 71.98,104.81 72.22,104.81 72.31,104.76 72.31,104.66 72.28,104.37 72.45,104.15 72.49,104.09 72.49,104.03 72.49,103.97 72.51,103.92 74.06,102.37 74.17,102.35 74.23,102.45 74.23,102.7 74.61,103.07 75.1,103.07 75.18,103.15 75.95,102.37 75.98,102.26 75.88,102.2 73.88,102.2 71.88,104.2 71.91,104.23 71.87,104.76 71.34,104.74 70.25,105.83 67.51,105.83 65.69,107.65 65.67,107.76 65.76,107.83 65.91,107.83 66.09,108.01 66.14,108.06 66.28,107.93 66.39,107.85 66.52,107.83 66.73,107.83 66.87,107.85 66.98,107.93 67.11,108.06
DGND on L05_SIG2 (solid shape): outline of 139 points within 56.7,125.18 86.4,130.62
DGND on L05_SIG2 (solid shape): 159.74,86.99 159.85,87.01 159.92,86.92 159.92,86.72 160.05,86.58 160.08,86.5 160.04,86.43 160.69,83.94 161.8,86.26 161.78,86.37 161.88,86.43 162.7,86.43 162.7,83.71 158.91,83.71 158.41,84.21 158.39,84.31 158.46,84.38 159.21,85.2 158.66,86.16 158.6,86.23 158.63,86.32 158.7,86.43 158.74,86.56 158.77,86.63 158.84,86.65 159.41,86.65
DGND on L05_SIG2 (solid shape): 54.7,108.64 54.76,108.64 54.81,108.59 54.11,107.89 54.11,107.81 54.07,107.73 53.98,107.71 53.49,107.35 53.98,106.98 54.07,106.97 54.11,106.89 54.11,105.95 54.05,105.85 53.94,105.87 52.79,107.03 52.61,107.03 52.53,107.07 52.52,107.16 52.16,107.67 51.8,107.16 51.79,107.07 51.7,107.03 49.44,107.03 48.59,107.87 48.57,107.99 48.66,108.05 49.19,108.05 49.27,108.01 49.29,107.92 49.66,107.44 50.03,107.92 50.04,108.01 50.12,108.05 51.95,108.05 52.55,108.65 54.65,108.65
DGND on L05_SIG2 (solid shape): 158.8,17.51 158.87,17.48 158.9,17.4 159.28,17.02 159.66,17.4 159.69,17.48 159.77,17.51 160.19,17.51 160.43,17.26 160.45,17.22 156.2,12.97 145.77,12.97 144.93,13.82 144.93,14.78 144.99,14.84 145.05,14.79 145.04,14.76 145.17,14.38 145.56,14.33 145.57,14.33 148.87,14.33 150.46,15.92 151.02,15.92 151.47,15.48 151.49,15.37 151.4,15.3 151.23,13.3 152.02,15.15 151.97,15.26 152.07,15.34 156.22,15.34 157.92,17.04 157.93,17.04 158.1,17.19 158.17,17.4 158.2,17.48 158.27,17.51
DGND on L05_SIG2 (solid shape): outline of 173 points within 134.96,109.16 141.62,113.27
DGND on L05_SIG2 (solid shape): outline of 181 points within 176.78,141.35 201.22,152.82
DGND on L05_SIG2 (solid shape): 152.31,17.24 152.39,17.2 152.41,17.12 152.78,16.64 153.15,17.12 153.17,17.2 153.25,17.24 153.33,17.24 153.33,17.18 153.32,17.17 153.51,16.67 154.01,16.85 154.09,16.9 154.17,16.87 154.45,16.6 154.43,16.56 154.32,16.45 151.91,16.45 151.37,16.98 147.73,16.98 147.72,16.99 147.19,16.64 147.72,16.29 147.73,16.29 149.6,16.29 149.7,16.23 149.68,16.12 148.58,15.02 145.57,15.02 145.5,15.05 145.44,15.06 145.36,15.12 145.38,15.23 145.45,15.3 145.46,15.3 145.72,15.45 145.79,15.75 145.81,15.84 145.89,15.87 146.02,15.87 146.46,16.32 146.47,16.32 146.71,16.68 146.46,17.03 146.4,17.11 146.43,17.2 146.47,17.24
DGND on L05_SIG2 (solid shape): 29.78,140.3 29.87,140.24 29.85,140.13 29.65,139.93 29.65,138.56 30.48,137.73 33.2,137.73 33.27,137.7 33.3,137.62 33.68,137.21 34.06,137.62 34.09,137.7 34.16,137.73 44.75,137.73 45.81,136.67 45.83,136.55 45.74,136.49 30.22,136.49 29.41,135.69 29.4,135.69 29.26,135.58 29.18,135.42 29.1,135.34 29,135.37 28.9,135.47 28.9,135.48 28.28,135.6 28.4,134.98 28.41,134.98 28.45,134.94 28.48,134.85 28.41,134.78 28.17,134.42 28.4,134.07 28.41,134.06 28.83,133.64 28.86,133.53 28.76,133.47 28.12,133.47 27.27,134.32 27.27,136.52 26.39,137.4 26.36,137.47 26.4,137.54 26.42,138.1 25.86,138.08 25.79,138.05 25.71,138.08 23.66,140.13 23.64,140.24 23.73,140.3
DGND on L05_SIG2 (solid shape): outline of 198 points within 171.44,49.52 180.53,63.15
DGND on L05_SIG2 (solid shape): outline of 195 points within 159.35,31.15 162.66,39.49
DGND on L05_SIG2 (solid shape): outline of 199 points within 170.04,95.84 172.03,100.49
DGND on L05_SIG2 (solid shape): 181.7,86.81 181.78,86.79 181.88,86.73 182,86.71 182.04,86.69 182.05,86.66 182.05,84.76 183.29,83.52 183.25,83.48 183.21,83.46 183.18,83.48 182.77,83.62 182.39,83.41 182.32,83.37 182.24,83.39 182.22,83.41 182.18,83.49 182.22,83.57 182.01,84.27 181.8,83.57 181.84,83.49 181.8,83.41 181.63,83.15 181.71,82.86 181.73,82.78 181.69,82.72 181.63,82.67 181.59,82.61 181.52,82.57 181.44,82.59 180.83,82.29 181.44,81.99 181.52,82.01 181.59,81.97 181.63,81.91 181.69,81.86 181.73,81.8 181.71,81.72 181.63,81.54 181.66,81.34 181.65,81.25 181.57,81.2 181.04,81.2 180.26,81.98 180.26,86.46 180.3,86.53 180.37,86.56 180.59,86.59 180.78,86.7 180.81,86.72 180.85,86.7 181.26,86.56 181.64,86.77
DGND on L05_SIG2 (solid shape): outline of 120 points within 68.81,99.3 88.62,100.44
DGND on L05_SIG2 (solid shape): outline of 256 points within 165.22,50.87 170.44,63.93
DGND on L05_SIG2 (solid shape): outline of 286 points within 54.77,96.29 63.74,104.63
DGND on L05_SIG2 (solid shape): outline of 305 points within 62.9,101.74 72.56,107.22
DGND on L05_SIG2 (solid shape): outline of 83 points within 180.26,87.37 183.29,100.52
DGND on L05_SIG2 (solid shape): outline of 337 points within 56.05,100.82 66.68,106.27
DGND on L05_SIG2 (solid shape): outline of 334 points within 113.78,113.62 132.35,118.79
DGND on L05_SIG2 (solid shape): outline of 356 points within 109.95,109.69 117.18,117.9
DGND on L05_SIG2 (solid shape): outline of 391 points within 94.15,100.44 111.01,107.86
DGND on L05_SIG2 (solid shape): outline of 406 points within 89.05,91.2 109,96.74
DGND on L05_SIG2 (solid shape): outline of 412 points within 141.51,92.36 144.02,97.16
DGND on L05_SIG2 (solid shape): outline of 552 points within 179.36,48.53 190.41,61.41
DGND on L05_SIG2 (solid shape): outline of 597 points within 141.18,40.94 161.16,46.84
DGND on L05_SIG2 (solid shape): outline of 734 points within 153.86,60.28 171.41,79.77
DGND on L05_SIG2 (solid shape): outline of 1268 points within 84.57,13.59 162.19,32.72
DGND on L05_SIG2 (solid shape): outline of 1339 points within 85.11,96.32 120.05,118.99
DGND on L05_SIG2 (solid shape): outline of 1470 points within 121.5,27.91 162.28,44.88
DGND on L05_SIG2 (solid shape): outline of 1658 points within 67.28,106.46 112.6,123.94
DGND on L05_SIG2 (solid shape): outline of 2055 points within 102.01,117.16 149.56,137.63
DGND on L05_SIG2 (solid shape): outline of 2109 points within 92.38,44.68 165.15,58.39
DGND on L05_SIG2 (solid shape): outline of 2514 points within 140.92,94.54 155.42,105.67
DGND on L05_SIG2 (solid shape): outline of 7107 points within 14.57,53.98 141.11,111.41
DGND on L05_SIG2 (solid shape): outline of 12703 points within 111.66,55.13 200.94,158.3
DGND on L05_SIG2 (solid shape): outline of 50445 points within 7.51,0.52 209.66,177.28
DGND on L10_SIG3 (solid shape): 171.39,102.36 169.35,102.36 169.35,103.17 169.34,103.19 169.36,103.25 171.39,103.25
DGND on L10_SIG3 (solid shape): 137.26,114.92 137.28,114.81 137.18,114.75 134.1,114.75 134.08,114.78 134.06,114.83 134.03,114.87 134.45,115.29 136.89,115.29
DGND on L10_SIG3 (solid shape): 88.55,111.61 88.6,111.57 74.28,97.25 74.05,97.25 73.95,97.31 73.98,97.42 88.19,111.64 88.47,111.64
DGND on L10_SIG3 (solid shape): 37.99,117.93 38.05,118.02 38.16,118 38.31,117.85 38.31,113.23 38.25,113.14 38.14,113.16 37.99,113.31
DGND on L10_SIG3 (solid shape): 80.82,43.73 80.93,43.75 81,43.65 81,43.31 77.43,39.75 77.09,39.75 77,39.81 77.02,39.92
DGND on L10_SIG3 (solid shape): 85.94,86.8 85.98,86.77 85.97,86.71 85.94,86.68 85.94,85.55 84.47,85.55 84.47,86.4 84.25,86.62 84.23,86.74 84.32,86.8
DGND on L10_SIG3 (solid shape): 142.24,116.04 142.26,115.93 142.16,115.87 139.59,115.87 139.31,116.14 139.29,116.25 139.39,116.32 141.96,116.32
DGND on L10_SIG3 (solid shape): 150.42,149.5 150.51,149.44 150.49,149.33 146.95,145.79 146.84,145.77 146.78,145.86 146.78,146.03 150.25,149.5
