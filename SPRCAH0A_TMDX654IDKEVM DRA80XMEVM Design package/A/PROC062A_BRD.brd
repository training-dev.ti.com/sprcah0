# Allegro board PROC062A_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VOUT_D12_BOOTMODE12: length 85.1
  TOP w0.132: R285.1 148.91,56.59 v1(148.33,56.01) 147.74,56.59 SW2.3 ; U34.N26 v1(148.76,88.19) ; v1(159.04,45.24) 159.48,44.79 159.48,43.66 158.99,43.17 154.52,43.17 151.61,40.26 145.42,40.26 143.07,42.61 140.04,42.61 v1(139.27,41.83)
  L03_SIG1 w0.084: v1(148.76,88.19) 148.94,88 148.94,87.79 149.23,87.5 149.23,84.53 149.12,84.42 149.12,78.27 150.52,76.87 150.52,72.25 151.25,71.52 151.25,61.46 148.59,58.8 148.21,58.8 147.56,58.15 147.56,56.77 v1(148.33,56.01)
  L12_SIG4 w0.084: v1(139.27,41.83) 139.7,42.27 139.7,44.2 141.86,46.35 141.86,48.2 143.51,49.85 143.51,52.9 146.62,56.01 v1(148.33,56.01)
  BOTTOM w0.132: J36.25 159.54,44.74 v1(159.04,45.24) ; R644.1 v1(139.27,41.83)
VOUT_D13_BOOTMODE13: length 86.7
  TOP w0.132: R280.1 148.78,57.86 v1(148.32,57.4) 147.87,57.86 SW2.4 ; U34.N25 v1(148.76,88.99)
  L03_SIG1 w0.084: v1(148.76,88.99) 148.76,88.74 149.16,88.33 149.16,88.03 149.41,87.78 151.39,87.78 151.67,87.5 151.67,86.54 149.43,84.3 149.43,78.4 150.83,77 150.83,74.34 151.56,73.61 151.56,60.64 v1(148.32,57.4)
  L05_SIG2 w0.084: v1(139.27,43.74) 140.35,42.66 142.51,42.66 144.89,40.28 157,40.28 160.49,43.78 160.49,44.51 160.23,44.78 159.49,44.78 v1(159.04,44.32)
  L12_SIG4 w0.084: v1(148.32,57.4) 147.26,57.4 142.49,52.64 142.49,49.8 139.27,46.57 v1(139.27,43.74)
  BOTTOM w0.132: R637.1 v1(139.27,43.74) ; J36.23 v1(159.04,44.32)
VOUT_D14_BOOTMODE14: length 101.1
  TOP w0.132: 148.32,58.97 148.16,59.13 SW2.5 ; 148.32,58.97 v1(148.32,58.32) ; 148.32,58.97 148.49,59.13 R276.1 ; U34.P24 v1(148.76,89.79)
  L03_SIG1 w0.084: v1(148.76,89.79) 148.94,89.6 148.94,89.44 149.16,89.21 149.16,88.83 149.39,88.6 151.3,88.6 151.89,88.01 151.89,86.23 149.73,84.07 149.73,81.66 150.5,80.9 150.5,77.88 151.86,76.51 151.86,59.79 148.59,56.52 148.25,56.52 147.87,56.9 147.87,57.85 148,57.98 148,58 v1(148.32,58.32)
  L05_SIG2 w0.084: v1(158.04,45.24) 158.58,45.78 161.14,45.78 161.49,45.43 161.49,43.89 156.73,39.13 145.18,39.13 143.23,41.08 139.32,41.08 137.77,42.64 v1(137.77,43.74)
  L12_SIG4 w0.084: v1(137.77,43.74) 137.77,45.5 141.37,49.11 141.37,52.66 147.03,58.32 v1(148.32,58.32)
  BOTTOM w0.132: J36.21 158.54,44.74 v1(158.04,45.24) ; R638.1 v1(137.77,43.74)
VOUT_D15_BOOTMODE15: length 78.7
  TOP w0.132: R272.1 149,60.35 148.34,59.7 v1(148.34,59.6) 148.34,59.61 148.29,59.61 147.5,60.4 SW2.6 ; U34.R27 v1(147.16,87.39) ; v1(137.77,41.83) 138.86,42.93 143.13,42.93 145.45,40.61 151.54,40.61 154.37,43.43 157.15,43.43 v1(158.04,44.32)
  L03_SIG1 w0.084: v1(148.34,59.6) 146.81,61.14 146.81,66.17 146.08,66.9 146.08,75.34 146.76,76.02 146.76,87 v1(147.16,87.39)
  L10_SIG3 w0.084: v1(148.34,59.6) 148.8,59.6 148.97,59.43 148.97,54.61 153.73,49.85 156.15,49.85 157.48,48.51 157.48,44.88 v1(158.04,44.32)
  BOTTOM w0.132: J36.19 v1(158.04,44.32) ; R645.1 v1(137.77,41.83)
VOUT_D16: length 51.5
  TOP w0.132: U34.R28 v1(147.16,86.59)
  L03_SIG1 w0.084: v1(148.27,60.52) 147.11,61.68 147.11,66.3 146.38,67.03 146.38,75.21 147.07,75.9 147.07,85.89 147.16,85.98 v1(147.16,86.59)
  L10_SIG3 w0.084: v1(148.27,60.52) 147.83,60.07 147.83,53.4 152.72,48.51 156.08,48.51 156.59,48.01 156.59,44.77 v1(157.04,44.32)
  BOTTOM w0.132: J36.15 v1(157.04,44.32)
VOUT_D17_BOOTMODE16: length 56.3
  TOP w0.132: U34.P25 v1(147.96,88.99) ; SW2.7 148.28,61.67 v1(148.32,61.72) 148.34,61.72 148.39,61.67 R258.1
  L03_SIG1 w0.084: v1(148.32,61.72) 147.45,62.6 147.45,71.88 148.21,72.64 148.21,82.87 147.56,83.51 147.56,88.6 v1(147.96,88.99)
  L10_SIG3 w0.084: v1(148.32,61.72) 147.68,61.07 147.68,60.35 147.37,60.04 147.37,53.43 153.37,47.43 v1(156.02,47.43)
  BOTTOM w0.132: v1(156.02,47.43) 156.02,45.72 156.54,45.2 J36.13 ; R603.1 147.81,61.7 148.31,61.7 v1(148.32,61.72)
VOUT_D18_BOOTMODE17: length 54.7
  TOP w0.132: R249.1 148.53,62.94 v1(148.32,62.74) 148.12,62.94 SW2.8 ; U34.P26 v1(147.96,88.19)
  L03_SIG1 w0.084: v1(147.96,88.19) 148.36,87.78 148.36,83.57 148.82,83.12 148.82,76.72 149.55,75.98 149.55,72.11 149.05,71.6 149.05,63.46 v1(148.32,62.74)
  L10_SIG3 w0.084: v1(156.04,45.14) 155.23,45.14 147.24,53.12 147.07,53.3 147.07,60.17 147.37,60.48 147.37,61.78 v1(148.32,62.74)
  BOTTOM w0.132: v1(156.04,45.14) 156.04,44.75 156.04,44.75 J36.11 ; v1(148.32,62.74) 148.16,62.91 R602.1
VOUT_D19_BOOTMODE18: length 114.8
  TOP w0.132: U34.U28 v1(145.56,86.59) ; SW2.9 147.75,64.21 v1(148.27,63.69) 148.79,64.21 R243.1
  L03_SIG1 w0.084: v1(145.56,86.59) 145.56,84.62 144.74,83.81 144.74,78.78 143.19,77.24 143.19,67.96 145.28,65.87 145.28,57.17 141.89,53.77 137.96,53.77 134.99,50.8 134.99,42.81 v1(135.89,41.91)
  L10_SIG3 w0.084: v1(155.54,41.17) 155.08,41.17 153.56,39.65 137.48,39.65 135.89,41.24 v1(135.89,41.91) 136.91,42.93 142.44,42.93 147.24,47.73 148.97,47.73 149.63,48.39 149.63,50.16 147.31,52.49 146.65,52.49 145.92,53.21 145.92,59.46 147.07,60.61 147.07,62.48 v1(148.27,63.69)
  BOTTOM w0.132: J36.9 v1(155.54,41.17) ; R601.1 148.04,63.93 v1(148.27,63.69)
VPHY_3V3_FT4232: length 6.1
  L05_SIG2 w0.203: v1(19.58,136.14) 18.03,137.69 v1(17.1,137.69)
  BOTTOM w0.254: U73.4 20.09,136.69 19.97,136.82 C331.2 v1(19.58,136.14) ; FL10.1 v1(17.1,137.69)
VPLL_3V3_FT4232: length 5.6
  BOTTOM w0.203: C324.2 19.71,139.45 19.51,139.66 17.79,139.66 17.71,139.57 FL9.1
  BOTTOM w0.254: R381.2 FL9.1 ; U73.9 C324.2
VPP_1V8: length 108.8
  TOP w0.254: U1.1 123.44,170.14 C5.1
  L08_PWR3 w0.254: 160.02,158.78 161.11,159.87 161.11,166.28 159.62,167.77 154.24,167.77 151.19,170.81 127.33,170.81
  L08_PWR3 w0.381: 160.02,158.78 160.02,150.75 161.11,149.66 161.11,139.76 163.2,137.67 163.2,135.64 161.29,133.73 161.29,115.82 159.39,113.92 149.04,113.92 146.8,116.16 v1(146.8,117.35)
  BOTTOM w0.254: v1(146.8,117.35) 147,117.14 FL17.1
VPP_CORE_MCU: length 1.6
  TOP w0.132: U34.F21 v1(155.16,92.19)
  TOP w0.254: U34.T6 v1(146.36,104.99)
  L10_SIG3 w0.381: v1(146.36,104.99) 146.34,104.99 146,104.65
VPP_LDO_EN: length 115.8
  TOP w0.132: TP80.1 120.75,166.95 v1(120.75,168.43) R6.2 U1.3 ; U34.R1 v1(147.16,108.99)
  L12_SIG4 w0.084: v1(120.75,168.43) 128.3,168.43 129.64,169.77 157.3,169.77 161.42,165.66 161.42,157.16 162.5,156.08 162.5,146.49 161.09,145.08 161.09,136.59 159.25,134.75 152.78,134.75 151.32,133.29 151.32,124.4 148.27,121.35 148.27,117.28 146.88,115.89 146.88,109.6 146.88,109.27 v1(147.16,108.99)
VREF: length 7.7
  BOTTOM w0.203: C654.1 45.16,21.32 U106.9
  BOTTOM w0.254: R663.2 U107.3 C655.1 C654.1
VSENSE: length 4
  BOTTOM w0.132: U80.6 45.26,127.37 45.16,127.27 C361.2 45.16,125.01 R425.2 R418.1
WKUP_GPIO0_13: length 12.9
  TOP w0.132: U52.5 114.02,44.27 111.58,41.83 111.58,37.95 v1(114.1,35.43)
  BOTTOM w0.132: U125.8 114.87,36.21 v1(114.1,35.43)
WKUP_GPIO0_13_INTN: length 109.9
  TOP w0.132: U34.R5 v1(147.16,105.79)
  L10_SIG3 w0.084: v1(147.16,105.79) 147.6,106.23 147.6,107.57 147.37,107.8 143.84,107.8 143.56,107.52 143.56,104.85 143.32,104.6 143.01,104.6 142.76,104.35 142.76,97.95 141.96,97.15 141.96,86.43 141.51,85.98 141.51,79.38 138.52,76.39 v1(138.52,75.66)
  BOTTOM w0.132: v1(138.52,75.66) 136.66,77.52 121.34,77.52 109.55,65.74 109.55,39.75 111.48,37.82 116.13,37.82 116.37,37.58 U125.5
WKUP_GPIO0_27: length 5.3
  TOP w0.132: U52.7 115.02,43.77 v1(113.98,42.74)
  BOTTOM w0.132: U125.1 114.87,40.83 114.48,41.22 114.48,42.24 v1(113.98,42.74)
WKUP_GPIO0_27_INTN: length 92.9
  TOP w0.132: U34.P2 v1(148.76,108.19)
  L03_SIG1 w0.084: v1(116.56,38.91) 115.44,40.03 115.44,45.97 125.41,55.94 125.41,70.68 135.64,80.9 138.81,80.9 142.75,84.83 142.75,92.39 142.94,92.58 147.57,92.58 147.83,92.84 147.83,101.98 147.61,102.2 146.18,102.2 145.97,102.41 145.97,103.61 146.15,103.8 147.32,103.8 148.21,104.69 148.21,107.44 148.76,107.99 v1(148.76,108.19)
  BOTTOM w0.132: v1(116.56,38.91) 116.37,39.1 U125.4
WKUP_LFOSC_RTC_XIN: length 70.4
  TOP w0.132: U34.AE4 v1(139.96,106.59)
  L10_SIG3 w0.084: v1(94.86,74.17) 96.05,75.36 99.82,75.36 100.15,75.69 104.9,75.69 115.42,86.21 115.42,98.5 118.59,101.68 118.9,101.68 119.61,100.96 121.54,100.96 124.61,104.04 131.72,104.04 134.05,106.36 137.35,106.36 137.53,106.18 139.55,106.18 v1(139.96,106.59)
  BOTTOM w0.132: R551.2 93.85,75.17 v1(94.86,74.17)
WKUP_LFOSC_XIN: length 2.3
  BOTTOM w0.132: R564.1 84.98,76.9 85.31,77.23 U91.1
WKUP_LFOSC_XOUT: length 2.3
  BOTTOM w0.132: R550.1 84.98,78.17 85.31,78.5 U91.2
WKUP_OSC0_XIN: length 72.5
  TOP w0.132: R769.2 v1(71.62,104.47)
  BOTTOM w0.132: v1(71.62,104.47) 72.66,103.43 91.16,103.43 101.7,113.97 109.04,113.97 109.35,113.67 113.77,113.67 114.33,114.22 114.33,116.41 115.19,117.27 120.75,117.27 121.74,116.28 121.74,114.29 122.43,113.6 122.43,112.34 124.03,110.74 128.32,110.74 129.32,109.74 R448.2
WKUP_OSC0_XIN_SOC: length 11.4
  TOP w0.132: U34.AD5 v1(139.96,105.79)
  BOTTOM w0.122: 136.18,105.89 136.42,105.89 136.92,105.38 139.42,105.38 139.83,105.79 v1(139.96,105.79)
  BOTTOM w0.132: 136.18,105.89 134.92,105.89 131.9,108.9 R450.1
WKUP_OSC0_XOUT: length 10.5
  TOP w0.132: U34.AE6 v1(139.16,104.99)
  BOTTOM w0.122: 139.05,104.91 139.13,104.99 v1(139.16,104.99)
  BOTTOM w0.132: 139.05,104.91 138.72,104.58 135.7,104.58 132.59,107.7 R457.1
WKUP_UART_SEL: length 137.8
  TOP w0.132: v1(110.74,115.09) 110.47,115.36 U23.6 109.08,115.36 108.43,116.02 R120.2
  L03_SIG1 w0.084: v1(110.74,115.09) 107.97,115.09 105.22,112.34 105.22,103.18 102.7,100.66 94.12,100.66 91.56,98.1 91.56,92.83 93.21,91.19 93.21,61.55 97.69,57.06 97.69,26.71 85.59,14.61 77.22,14.61 76.77,15.06 v1(76.77,15.51)
  BOTTOM w0.132: v1(110.74,115.09) 110.52,114.86 U83.6 ; v1(76.77,15.51) 77.27,16.01 U110.14
XDS110_DIR: length 2.9
  BOTTOM w0.132: 59.18,53.21 59.02,53.05 U98.3 ; 59.18,53.21 58.84,53.55 U98.2 ; 59.18,53.21 59.44,53.47 R621.2
XDS110_EMU0: length 9
  BOTTOM w0.132: U103.8 51.02,39.75 51.12,39.65 51.12,36.13 50.8,35.81 50.8,34.54 51.34,34 R655.2 51.37,33.33 51.69,33.01 U106.42
XDS110_EMU1: length 9.1
  BOTTOM w0.132: U106.43 52.09,33.03 52.39,33.33 R654.2 52.42,34 53.02,34.6 53.02,35.69 52.58,36.13 52.58,39.59 52.74,39.75 U103.1
XDS110_TCK: length 18
  TOP w0.132: v1(44.09,56.8) 50.31,56.8 54.37,52.74 54.37,52.34 54.14,52.11 52.77,52.11 v1(52.32,52.55)
  BOTTOM w0.132: v1(52.32,52.55) 52.82,52.05 U98.12 ; R609.2 v1(44.09,56.8)
XDS110_TDI: length 17.9
  TOP w0.132: v1(39.18,56.57) 40.65,56.57 42.8,54.42 52.06,54.42 v1(53.93,52.55)
  BOTTOM w0.132: R612.2 v1(39.18,56.57) ; v1(53.93,52.55) U98.13
XDS110_TDO: length 6.1
  TOP w0.132: v1(41.21,60.34) 41.72,59.82 41.72,58.32 41.72,58.32 v1(41.72,56.57)
  BOTTOM w0.132: U97.7 41.7,59.6 41.53,59.77 41.53,60.02 v1(41.21,60.34) ; R611.2 v1(41.72,56.57)
XDS110_TMS: length 19.6
  TOP w0.132: v1(53.93,51.55) 52.89,51.55 52.44,52 51.5,52 49.47,54.04 42.8,54.04 40.83,56.01 38.47,56.01 v1(37.91,56.57)
  BOTTOM w0.132: U98.11 v1(53.93,51.55) ; R613.2 v1(37.91,56.57)
XDS110_TRST#: length 26.3
  TOP w0.132: v1(37.91,38.93) 37.91,44.39 45.08,51.55 v1(52.26,51.55)
  BOTTOM w0.132: U98.10 52.76,51.05 v1(52.26,51.55) ; R646.2 v1(37.91,38.93)
XDS_SHIELD: length 3.3
  TOP w0.254: J23.SH1 99.49,2.87 100.37,3.75 J23.SH3
  vias: v1(98.22,0.81) v1(98.25,2.31)
XDS_USB_DM: length 55.9
  TOP w0.104: J23.2 104.09,4.87 103.87,5.09 103.87,5.72 v1(104.28,6.13) 103.99,6.13 103.87,6.24 103.87,6.43 103.93,6.49 103.93,6.77 U58.5
  L05_SIG2 w0.089: v1(104.28,6.13) 103.97,6.13 103.89,6.21 103.89,7.07 101.83,9.13 96.16,9.13 95.9,9.4 71.86,9.4 62.01,19.24 60.19,19.24 60.1,19.33 v1(60.1,19.63)
  BOTTOM w0.104: U106.93 60.41,19.32 v1(60.1,19.63)
XDS_USB_DP: length 55.9
  TOP w0.104: J23.3 103.44,4.88 103.66,5.09 103.66,5.72 v1(103.26,6.13) 103.57,6.13 103.66,6.21 103.66,6.43 103.59,6.5 103.59,6.78 U58.4
  L05_SIG2 w0.089: v1(103.26,6.13) 103.58,6.13 103.67,6.21 103.67,6.98 101.74,8.92 96.07,8.92 95.81,9.18 71.77,9.18 61.92,19.02 60.19,19.02 60.1,18.94 v1(60.1,18.61)
  BOTTOM w0.104: v1(60.1,18.61) 60.1,18.85 60.36,19.1 60.83,19.1 60.99,18.94 61.98,18.94 U106.94
XDS_USB_ID: length 51.5
  TOP w0.132: J23.4 102.79,4.97 102.49,5.27 102.49,8.18 v1(103.53,9.22) 104.02,8.74 U58.2
  L05_SIG2 w0.084: v1(103.53,9.22) 102.44,10.31 73.26,10.31 v1(64.36,19.21)
  BOTTOM w0.132: R665.2 v1(64.36,19.21)
XDS_USB_VBUS: length 60.7
  TOP w0.254: 105.03,6.85 105.03,9.14 106.3,10.42 107.19,10.42 107.48,10.12 U57.8 ; 105.03,6.85 C250.1 v1(105.79,6.16) ; 105.03,6.85 U58.6 104.52,6.75 104.9,6.37 104.9,5.21 104.74,5.05 J23.1
  L05_SIG2 w0.203: v1(62.29,14.65) 69.6,7.34 100.84,7.34 102.72,5.46 105.09,5.46 v1(105.79,6.16)
  BOTTOM w0.132: v1(62.29,14.65) 62.74,14.65 62.81,14.58 R678.1 R670.1
N5126218: length 2.2
  BOTTOM w0.132: R501.2 J14.A12
N5126260: length 19.4
  TOP w0.132: U31.13 49.07,98.06 48.79,97.78 46.73,97.78 v1(45.21,96.27) 45.56,95.92 TP16.1 ; U31.48 49.07,105.99 48.77,106.29 v1(47.48,106.29)
  L03_SIG1 w0.084: v1(47.48,106.29) 46.86,105.68 46.86,97.92 v1(45.21,96.27)
N15202140: length 1.5
  BOTTOM w0.132: U106.95 R665.1
N15204440: length 4.1
  TOP w0.132: U57.5 R333.1 R334.2 111.68,10.82 111.71,10.85 C249.2
N15205319: length 2.8
  BOTTOM w0.132: U106.68 62.95,29.32 C645.1 63.41,30.73 R657.1
N15205492: length 6.3
  TOP w0.132: R324.1 R322.1 63.52,27.43 R323.1 61.99,27.34 v1(60.81,28.52)
  BOTTOM w0.132: v1(60.81,28.52) U106.70
N15212041: length 2.6
  BOTTOM w0.132: R653.1 57.86,34.31 58.29,33.88 58.29,33.4 58.49,33.2 U106.59
N15239696: length 2.9
  BOTTOM w0.132: R670.2 C665.1 63.55,17.46 62.89,18.12 U106.96
N15241750: length 19.8
  L10_SIG3 w0.084: v1(47.75,17.88) 58.24,17.88 v1(62.38,13.74)
  BOTTOM w0.132: U106.1 47.52,18.12 v1(47.75,17.88) ; R677.1 R678.2 v1(62.38,13.74)
N15242949: length 55.1
  TOP w0.132: R335.1 v1(96.65,8.32)
  L05_SIG2 w0.084: v1(96.65,8.32) 69.72,8.32 59.88,18.16 48.53,18.16 v1(47.77,18.92)
  BOTTOM w0.132: v1(47.77,18.92) U106.3
N15242980: length 2.6
  TOP w0.132: R335.2 99.12,8.32 99.43,8.63 LD20.2
N15243226: length 54.8
  TOP w0.132: R332.1 v1(96.65,13.65)
  L05_SIG2 w0.084: v1(48.7,18.92) 50.76,20.98 64.3,20.98 70.48,14.8 95.5,14.8 v1(96.65,13.65)
  BOTTOM w0.132: U106.4 47.54,19.32 47.59,19.37 48.26,19.37 48.39,19.24 48.39,19.24 v1(48.7,18.92)
N15352717: length 4.7
  BOTTOM w0.132: U77.C3 145.59,130.26 148.55,130.26 149.23,129.57 R410.1
N15365714: length 3.7
  BOTTOM w0.132: J41.27 125.85,9.3 126.92,10.38 R690.2
N15365947: length 3.5
  BOTTOM w0.132: R692.2 124.89,10.38 124.35,9.83 J41.30
N15366015: length 3.3
  BOTTOM w0.132: J41.31 123.85,8.1 123.89,8.14 R693.2
N15366091: length 3.4
  BOTTOM w0.132: R694.2 122.87,9.4 123.35,8.92 J41.32
N15507744: length 1
  BOTTOM w0.132: U76.2 10.92,132.84
N15584817: length 2.1
  TOP w0.132: SW3.17 R281.2
N15584821: length 2.1
  TOP w0.132: SW3.18 R286.2
N15584825: length 2.1
  TOP w0.132: SW3.19 R292.2
N15584829: length 2.1
  TOP w0.132: SW3.20 R296.2
N15591045: length 2.1
  TOP w0.132: SW3.13 R250.2
N15591049: length 2.1
  TOP w0.132: SW3.14 R259.2
N15591053: length 2.1
  TOP w0.132: SW3.15 R273.2
N15591057: length 2.1
  TOP w0.132: SW3.16 R277.2
N15697942: length 2.3
  BOTTOM w0.132: R449.2 J12.11
N15698204: length 14.9
  TOP w0.132: U22.13 34.33,111.21 34.06,110.93 v1(32.74,110.93) ; U22.48 33.3,118.89 v1(32.74,119.44) 32.43,119.76 32.43,120.04 TP12.1
  L10_SIG3 w0.084: v1(32.74,110.93) 33.53,111.72 33.53,118.66 v1(32.74,119.44)
N15808488: length 2.2
  TOP w0.132: U20.B9 181.48,129.57 181.48,130.18 181.92,130.62 R75.1
N15808528: length 3.2
  TOP w0.132: TP8.1 U16.A3
N15808578: length 3.2
  TOP w0.132: TP11.1 U20.A3
N15808694: length 3.2
  TOP w0.132: TP13.1 U25.A3
N15808746: length 2.4
  TOP w0.132: R52.1 181.92,144.64 181.75,144.46 181.74,144.46 181.36,144.08 181.36,143.41 U16.B9
N15808770: length 3.2
  TOP w0.132: TP15.1 U33.A3
N15812130: length 2.2
  TOP w0.132: R166.1 181.92,103.18 181.56,102.82 181.56,102.72 181.48,102.64 181.48,102.13 U33.B9
N15812170: length 2.2
  TOP w0.132: R117.1 181.92,116.9 181.48,116.46 181.48,115.85 U25.B9
N15820521: length 1.4
  TOP w0.132: U38.E7 v1(183.61,87.09)
  BOTTOM w0.132: v1(183.61,87.09) 183.62,87.08 R516.2
N15820751: length 3.2
  TOP w0.132: TP18.1 U38.A3
N15820885: length 2.2
  TOP w0.132: U38.B9 181.56,88.34 181.56,89.1 181.92,89.47 R212.1
N15854221: length 23.9
  TOP w0.132: v1(114.17,101.35) 114.67,101.84 114.67,102.42 114.53,102.56 C440.2 114.53,103.28 114.28,103.53 U27.8 114.28,105.39 114.42,105.54 114.68,105.54 114.78,105.44 U27.9
  BOTTOM w0.132: v1(114.17,101.35) 114.17,101.32 114.58,100.91 115.24,100.91 115.49,101.17 115.49,101.47 115.14,101.83 115.14,103.48 111.99,106.63 106.78,106.63 105.99,107.42 105.99,108.97 106.4,109.37 106.6,109.37 106.73,109.24 R715.1
N15854243: length 19.7
  TOP w0.132: v1(115.04,101.35) 114.94,101.46 114.94,102.36 115.09,102.51 C440.1 115.09,103.28 115.28,103.46 U27.10
  BOTTOM w0.132: v1(115.04,101.35) 114.81,101.59 114.81,103.4 111.89,106.32 106.71,106.32 105.71,107.31 105.71,109.07 106.3,109.65 106.57,109.65 106.73,109.81 R714.1
N15854325: length 5.8
  TOP w0.132: R148.1 111.84,106.98 112.21,106.61 113.85,106.61 114.28,107.04 U27.3
N15854335: length 4.9
  TOP w0.132: U3.3 184.96,160.64 184.75,160.43 R18.1
N15854337: length 10.5
  TOP w0.132: v1(185.34,152.6) 185.46,152.72 U3.9 185.46,159.22 185.29,159.38 185.11,159.38 184.96,159.24 U3.8
  BOTTOM w0.132: v1(185.34,152.6) 186.16,153.42 C279.2 186.16,154.32 R713.1
N15854349: length 9.9
  TOP w0.132: v1(186.26,152.6) 185.96,152.9 U3.10
  BOTTOM w0.132: v1(186.26,152.6) 185.86,152.21 185.18,152.21 184.95,152.44 184.95,152.98 185.58,153.62 C279.1 185.6,154.32 R712.1
N15854407: length 2.3
  BOTTOM w0.132: U68.3 R363.1
N15854417: length 10.2
  BOTTOM w0.132: C286.2 127.48,151.66 126.9,152.24 126.9,152.89 127.16,153.15 131.3,153.15 131.48,153.33 R709.1 ; C286.2 128.17,151.69 U68.9 ; C286.2 128.61,151.19 U68.8
N15854427: length 8.8
  BOTTOM w0.132: U68.10 128.17,152.19 C286.1 127.3,152.22 127.17,152.35 127.17,152.75 127.3,152.88 132.18,152.88 132.42,153.13 R708.1
N15854463: length 1.6
  BOTTOM w0.132: U67.3 R358.1
N15854467: length 7.4
  BOTTOM w0.132: R711.1 C280.2 150.39,155.78 150.13,155.51 149.67,155.51 148.51,154.35 U67.9 146.48,154.35 146.39,154.26 146.39,153.97 146.5,153.85 U67.8
N15854483: length 4.1
  BOTTOM w0.132: U67.10 148.5,154.85 149.43,155.78 149.73,155.78 149.83,155.88 C280.1 R710.1
N15854545: length 5.1
  BOTTOM w0.132: U93.3 184.08,70.16 182.33,68.41 R591.1
N15854547: length 3.9
  TOP w0.132: R14.1 155.85,167.66 155,166.82 155,165.78 155.5,165.29 U2.3
N15854553: length 8
  TOP w0.132: v1(179.2,70.99) 179.68,70.51 180.85,70.51 C218.2 181.8,70.64 R717.1
  BOTTOM w0.132: v1(179.2,70.99) 179.2,70.48 179.52,70.16 U93.8 181.86,70.16 181.99,70.29 181.99,70.52 181.85,70.66 U93.9
N15854557: length 6.8
  TOP w0.132: v1(150.01,164.71) 150.46,164.71 150.54,164.79 U2.9 152.9,164.79 153.03,164.92 153.03,165.16 152.9,165.29 U2.8
  BOTTOM w0.132: R719.1 151.75,164.88 151.56,165.07 C273.2 150.38,165.07 v1(150.01,164.71)
N15854581: length 7
  TOP w0.132: U2.10 150.24,164.29 150.15,164.2 149.82,164.2 149.54,164.47 149.54,165.67 v1(149.86,165.99)
  BOTTOM w0.132: v1(149.86,165.99) 150.22,165.63 C273.1 151.56,165.63 151.75,165.82 R718.1
N15854603: length 7
  TOP w0.132: v1(178.28,70.99) 178.6,70.68 178.88,70.68 179.48,70.08 C218.1 181.8,70.08 R716.1
  BOTTOM w0.132: v1(178.28,70.99) 178.68,71.39 179.36,71.39 179.59,71.16 U93.10
N15854669: length 1.6
  BOTTOM w0.132: U69.3 R364.1
N15854673: length 7.5
  BOTTOM w0.132: R723.1 C292.2 175.54,150.88 174.18,149.52 U69.9 171.74,149.52 171.61,149.38 171.61,149.15 171.74,149.02 U69.8
N15854685: length 4.6
  BOTTOM w0.132: U69.10 174.27,150.02 175.11,150.85 175.11,151.26 C292.1 R722.1
N15854737: length 1.6
  BOTTOM w0.132: U70.3 R365.1
N15854741: length 10.3
  BOTTOM w0.132: R721.1 164.56,150.94 164.56,150.72 164.47,150.62 164.01,150.62 164.01,150.62 160.65,150.62 160.4,150.37 160.4,149.73 160.78,149.35 161.06,149.35 C293.2 161.19,149.27 U70.9 163.53,149.27 163.62,149.18 163.62,148.89 163.51,148.77 U70.8
N15854757: length 7.5
  BOTTOM w0.132: R720.1 165.1,150.91 165.1,150.62 164.73,150.25 160.8,150.25 160.67,150.12 160.67,149.87 160.8,149.73 161.09,149.73 C293.1 161.19,149.77 U70.10
N15854857: length 2.6
  TOP w0.132: J21.2 R326.2
N15854859: length 2.6
  TOP w0.132: J21.1 R325.2
N16248811: length 3.9
  TOP w0.132: U32.20 72.13,102.05 71.88,102.3 v1(71.87,102.3) 71.62,102.56 R769.1
  BOTTOM w0.132: C716.1 72.67,101.43 72.65,101.45 R770.1 72.12,101.99 72.01,102.11 72.01,102.17 71.88,102.3 v1(71.87,102.3)
N16248833: length 2
  TOP w0.132: U32.18 73.13,101.78 73.28,101.93 73.28,102.34 72.66,102.96 R169.1
N16248855: length 1.7
  TOP w0.132: R170.1 73.66,102.45 73.63,102.42 U32.17
N16248877: length 2
  TOP w0.132: R207.1 74.16,94.53 73.63,95.05 U32.8
N16248899: length 1.8
  TOP w0.132: R206.1 73.15,95.04 73.13,95.06 U32.7
N16248921: length 1.8
  TOP w0.132: U32.5 72.13,95.04 72.14,95.04 R205.1
N16248943: length 1.8
  TOP w0.132: R204.1 71.12,95.04 71.13,95.05 U32.3
N16248965: length 3
  TOP w0.132: U32.1 70.13,96.04 69.79,95.7 68.9,95.7 68.45,95.25 R203.1
N16295803: length 2.1
  TOP w0.132: SW3.12 R244.2
N16300126: length 2.1
  TOP w0.132: SW3.11 R239.2
N16303893: length 1.6
  TOP w0.132: R279.2 SW2.17
N16303897: length 1.6
  TOP w0.132: SW2.18 R284.2
N16303901: length 1.6
  TOP w0.132: R290.2 SW2.19
N16303905: length 1.6
  TOP w0.132: SW2.20 R294.2
N16303913: length 1.6
  TOP w0.132: SW2.13 R248.2
N16303917: length 1.6
  TOP w0.132: R257.2 SW2.14
N16303921: length 1.6
  TOP w0.132: R271.2 SW2.15
N16303925: length 1.6
  TOP w0.132: SW2.16 R275.2
N16303929: length 1.6
  TOP w0.132: R242.2 SW2.12
N16457366: length 4.8
  BOTTOM w0.132: R450.2 129.7,108.72 R455.1 128.64,108.71 127.97,108.71 127.76,108.5 C401.1 126.52,108.5 Y3.3
N16457370: length 6.9
  BOTTOM w0.132: R457.2 129.7,107.88 R455.2 128.1,107.88 127.74,107.52 C412.1 127.19,107.52 126.48,108.23 124.96,108.23 Y3.1
N16458713: length 6.4
  BOTTOM w0.132: R507.2 166.77,87.99 166.86,87.9 R510.1 168.46,87.9 C584.1 168.58,87.98 169.29,87.26 170.81,87.26 Y4.3
N16458717: length 4.4
  BOTTOM w0.132: R511.2 166.77,86.98 166.86,87.06 R510.2 168.46,87.06 C587.1 168.7,86.81 169.42,86.81 Y4.1
N16460347: length 4.9
  BOTTOM w0.132: R564.2 82.93,77.11 R563.1 80.84,77.11 C602.1 79.46,77.04 Y5.2
N16460351: length 4.9
  BOTTOM w0.132: Y5.1 79.46,78.03 C600.1 80.84,77.95 R563.2 82.93,77.95 R550.2
N16489740: length 2.7
  BOTTOM w0.132: R551.1 R552.1 92.82,77.91 92.24,78.5 U91.7
N16493735: length 51.3
  BOTTOM w0.381: B1.1 96.14,66.55 93.6,69.09 81.15,69.09 76.2,74.04 76.2,79.5 77.09,80.39 82.42,80.39 83.76,79.06 84.47,79.06 85.18,79.77 U91.3
N16679303: length 3.5
  TOP w0.132: v1(58.89,33.53) 58.89,33.98 58.86,34.01 R313.1 R312.2
  BOTTOM w0.132: U106.60 v1(58.89,33.53)
N16679944: length 3.8
  BOTTOM w0.132: R649.1 R650.2 60.9,33.85 60.09,33.04 U106.63
N16679981: length 3.7
  BOTTOM w0.132: U106.61 59.29,33.85 59.88,34.44 R651.1 R652.2
N16680014: length 3.5
  TOP w0.132: v1(59.89,33.48) 59.89,33.93 59.88,33.94 R314.1 R315.2
  BOTTOM w0.132: v1(59.89,33.48) 59.69,33.28 U106.62
N16753626: length 3.3
  BOTTOM w0.132: J32.6 R472.2
N16753680: length 2.3
  BOTTOM w0.132: J32.15 R478.2
N16754334: length 3.5
  BOTTOM w0.132: J32.12 97.21,97.97 96.55,97.31 R479.2
N16818481: length 13.8
  TOP w0.132: v1(10.3,167.88) 10.1,167.68 LD6.1
  BOTTOM w0.132: v1(10.3,167.88) 21.72,167.88 21.92,167.67 Q8.3
N16818579: length 3.8
  BOTTOM w0.132: Q8.1 D14.1 R346.2
N16818604: length 1.9
  BOTTOM w0.132: R362.2 U66.1
N16818646: length 2.6
  TOP w0.132: LD6.2 13.66,166.8 13.66,166.8 R13.2
N16818667: length 2.1
  BOTTOM w0.132: U66.9 32.26,154.01 32.72,153.54 R359.2
N16818684: length 1.6
  BOTTOM w0.132: U66.7 C281.1
N16818713: length 1.4
  TOP w0.132: LD5.2 R9.2
N16818872: length 4.2
  BOTTOM w0.132: U66.4 27.89,155.01 28.08,155.2 R351.2 R350.1
N16818874: length 5
  BOTTOM w0.132: R354.2 25.76,156.58 ; 25.76,156.58 25.92,156.41 25.92,154.92 26.34,154.51 U66.3 ; 25.76,156.58 25.92,156.74 R353.1
N16865556: length 2.2
  BOTTOM w0.132: FL12.2 J14.A9
N16865678: length 5.1
  BOTTOM w0.254: FL11.2 J12.2
N16937764: length 2.1
  TOP w0.132: R241.1 114.41,64.99 114.35,65.06 U43.5
N16938293: length 1.7
  BOTTOM w0.132: U98.5 R623.1
N17211229: length 3.7
  BOTTOM w0.132: R695.2 121.86,9.66 122.85,8.68 J41.33
N17247526: length 1.8
  TOP w0.132: R107.2 LD11.2
N17247539: length 1.8
  TOP w0.132: R108.2 LD12.2
N17247599: length 1.8
  TOP w0.132: R109.2 LD13.2
N17247637: length 1.8
  TOP w0.132: R110.2 LD14.2
N17247662: length 1.8
  TOP w0.132: LD10.2 R106.2
N17247701: length 1.8
  TOP w0.132: LD15.2 R105.2
N17247743: length 1.8
  TOP w0.132: LD9.2 R104.2
N17247786: length 1.8
  TOP w0.132: LD8.2 R103.2
N17248427: length 1.6
  BOTTOM w0.132: R431.2 66.59,117.27 U84.7
N17248432: length 1.6
  BOTTOM w0.132: U84.10 R453.2
N17248439: length 1.6
  BOTTOM w0.132: U84.9 R454.2
N17309165: length 1.6
  BOTTOM w0.132: U111.9 144.55,14.17 R676.2
N17314921: length 1.8
  BOTTOM w0.132: R679.2 139.32,14.18 U111.12
N17368941: length 1.6
  BOTTOM w0.132: U65.7 123.74,155.15 124.05,155.46 R356.1
N17368953: length 1.6
  BOTTOM w0.132: U83.7 108.82,115.36 108.51,115.05 R440.1
N17372472: length 1.7
  BOTTOM w0.132: R452.2 U85.5
N17372478: length 2.5
  BOTTOM w0.132: U85.4 83.13,109.47 83.27,109.6 84.19,109.6 84.33,109.74 R447.1
N17372544: length 1.7
  TOP w0.132: R80.2 112.58,128.29 112.26,128.61 U19.5
N17372552: length 2.4
  TOP w0.132: R89.1 112.28,127.84 112.15,127.98 111.35,127.98 111.09,128.24 U19.4
N17372616: length 1.7
  TOP w0.132: R116.2 110.49,118.61 110.81,118.92 U21.5
N17372624: length 2.4
  TOP w0.132: R113.1 110.04,119.09 110.17,119.22 110.17,120.02 110.43,120.28 U21.4
N17372676: length 1.7
  TOP w0.132: R42.2 116.85,149 116.53,149.31 U12.5
N17372684: length 2.4
  TOP w0.132: U12.4 115.18,148.94 115.44,148.68 116.24,148.68 116.37,148.55 R51.1
N17402100: length 1.6
  BOTTOM w0.132: U100.10 R624.1
N17546132: length 3.9
  BOTTOM w0.132: J41.26 126.35,8.78 127.94,10.38 R689.2
N17546158: length 3.5
  BOTTOM w0.132: J41.28 125.35,9.81 125.91,10.38 R691.2
N17682848: length 4.9
  BOTTOM w0.132: R708.2 133.26,153.73 132.39,154.6 132.39,156.11 132.73,156.45 R355.4
N17682861: length 4.9
  BOTTOM w0.132: R355.1 131.82,156.45 132.13,156.13 132.13,154.61 131.75,154.23 131.2,154.23 131.14,154.17 131,154.03 131,154.02 R709.2
N17683733: length 4.3
  BOTTOM w0.132: R710.2 148.04,156.73 148.15,156.84 149.6,156.84 149.73,156.98 149.73,157.66 149.64,157.75 148.52,157.75 R349.3
N17683748: length 4.8
  BOTTOM w0.132: R349.2 150.11,157.75 150,157.63 150,156.98 150.13,156.84 152.07,156.84 152.18,156.73 R711.2
N17685192: length 5.1
  BOTTOM w0.132: R348.3 185.74,157.24 185.98,157 185.98,156.63 185.49,156.14 185.49,155.28 185.35,155.14 184.7,155.14 184.57,155.01 R712.2
N17685207: length 5.9
  BOTTOM w0.132: R348.2 186.47,157.24 186.26,157.02 186.26,156.51 185.75,156.01 185.75,155.28 185.88,155.14 187.07,155.14 187.19,155.03 R713.2
N17685595: length 4.6
  BOTTOM w0.132: R459.1 109.43,110.85 108.94,110.36 107.49,110.36 107.34,110.52 107.34,111 107.2,111.14 R714.2
N17685608: length 6.1
  BOTTOM w0.132: R459.4 109.43,109.62 108.97,110.08 107.49,110.08 107.24,109.83 107.24,108.05 107.12,107.94 R715.2
N17685678: length 3.8
  TOP w0.132: R716.2 182.51,69.05 182.63,69.16 182.63,69.98 182.87,70.22 183.53,70.22 183.78,69.97 R234.1
N17685693: length 3.8
  TOP w0.132: R234.4 183.78,70.88 183.38,70.48 182.88,70.48 182.63,70.74 182.63,71.56 182.51,71.67 R717.2
N17685736: length 5.2
  BOTTOM w0.132: R718.2 152.63,166.66 152.78,166.51 152.78,165.48 153.03,165.24 154.94,165.24 155.14,165.44 R342.1
N17685749: length 4.8
  BOTTOM w0.132: R719.2 152.78,164.05 152.91,164.18 152.91,164.84 153.04,164.97 155.01,164.97 155.14,164.85 R342.4
N17686321: length 3.6
  BOTTOM w0.132: R720.2 166.15,151.36 165.86,151.65 165.21,151.65 164.98,151.88 164.98,152.55 165.1,152.67 R361.2
N17686333: length 3.7
  BOTTOM w0.132: R361.3 164.58,152.67 164.72,152.53 164.72,151.76 164.59,151.64 163.71,151.64 163.54,151.47 R721.2
N17686697: length 5.2
  BOTTOM w0.132: R360.3 175.17,153.05 175.26,152.95 175.26,152.15 175,151.89 172.81,151.89 172.68,151.76 R722.2
N17686710: length 4.4
  BOTTOM w0.132: R723.2 177.33,151.76 177.2,151.89 175.77,151.89 175.52,152.14 175.52,152.94 175.63,153.05 R360.2
N17781485: length 6.2
  BOTTOM w0.457: 32.96,67.06 U94.6
  BOTTOM w0.762: L11.1 32.96,67.06
N17781689: length 6.3
  BOTTOM w0.305: L6.1 164.33,166.09 164.77,166.53 U63.2
N17781701: length 3.2
  TOP w0.132: v1(166.85,165.1) 167.32,165.57 R16.2 R15.1
  BOTTOM w0.132: v1(166.85,165.1) 166.57,165.38 166.57,165.81 U63.4
N17781734: length 6.5
  BOTTOM w0.254: 184.79,172.41 U59.B4 U59.B3
  BOTTOM w0.762: 184.79,172.41 182.26,172.41 181.25,173.42 L3.1
N17785459: length 2.5
  BOTTOM w0.132: U80.7 43.84,128.28 C357.1 43.83,127.23 R414.1
N17785463: length 1.5
  BOTTOM w0.132: C359.2 42.15,127.18 42.17,127.19 R414.2
N17785477: length 13
  L03_SIG1 w0.203: v1(42.67,129.13) 43.92,129.13 45.09,130.3 49.05,130.3 v1(49.38,129.97)
  BOTTOM w0.254: C356.2 42.82,129.28 v1(42.67,129.13)
  BOTTOM w0.279: 49.02,129.28 U80.2 ; L9.1 v1(49.78,129.28)
  BOTTOM w0.508: v1(49.78,129.28) 49.02,129.28
  vias: v1(55.02,131.27) v1(55.83,131.27) v1(55.83,130.61) v1(56.59,130.61) v1(56.59,129.92)
N17785481: length 1.4
  BOTTOM w0.132: C356.1 U80.9
N17785497: length 2.2
  BOTTOM w0.132: R419.2 43.73,124.93 43.77,124.97 R425.1 44.24,125.01 C361.1
N17785692: length 1
  BOTTOM w0.132: C269.2 112.84,165.96 U64.7
N17785694: length 1.1
  BOTTOM w0.132: U64.8 112.83,166.52 C269.1
N17785722: length 2.4
  BOTTOM w0.132: R344.2 R343.1 U64.5
N17786037: length 2.3
  TOP w0.305: 34.35,78.38 33.76,77.79 U40.2
N17786049: length 2.8
  TOP w0.254: v1(35.24,75.93) 35.1,76.07 U40.4
  BOTTOM w0.132: v1(35.24,75.93) 34.86,75.55 R566.2 34.84,75.14 R567.1
N17817176: length 22.1
  TOP w0.132: U34.A7 v1(159.16,104.19)
  BOTTOM w0.122: v1(159.16,104.19) 159.55,104.19 159.77,104.41
  BOTTOM w0.132: TP41.1 169.01,115.82 160.66,107.47 160.66,105.3 159.77,104.41
N17817178: length 20.7
  TOP w0.132: U34.B7 v1(158.36,104.19)
  BOTTOM w0.122: 159.76,105.03 159.38,104.65 158.81,104.65 v1(158.36,104.19)
  BOTTOM w0.132: TP39.1 169.91,117.09 160.39,107.58 160.39,105.66 159.76,105.03
N17817198: length 22.5
  TOP w0.132: U34.C12 v1(157.56,100.19)
  BOTTOM w0.122: v1(157.56,100.19) 157.96,100.6 159.32,100.6 159.77,101.05
  BOTTOM w0.132: TP45.1 166.32,112.01 161.45,107.14 161.45,103.86 159.95,102.37 159.95,101.24 159.77,101.05
N17817246: length 24
  TOP w0.132: U34.F9 v1(155.16,102.59)
  BOTTOM w0.122: v1(155.16,102.59) 155.56,103 155.56,103.55 155.79,103.78 159.51,103.78
  BOTTOM w0.132: 159.51,103.78 160.92,105.19 160.92,107.36 168.11,114.55 TP42.1
N17817413: length 11.1
  TOP w0.132: R186.1 162.79,100.33 162.34,100.77 v1(162.34,101.22) ; U34.F13 v1(155.16,99.39)
  L05_SIG2 w0.084: v1(162.34,101.22) 162.34,100.93 160.42,99 159.77,99 159.77,99 155.55,99 v1(155.16,99.39)
N17817732: length 26.7
  TOP w0.132: U34.F10 v1(155.16,101.79)
  BOTTOM w0.122: v1(155.16,101.79) 155.56,102.2 159.41,102.2 159.77,102.55
  BOTTOM w0.132: 159.77,102.55 161.18,103.97 161.18,107.25 167.22,113.28 TP44.1
N17818942: length 31.2
  TOP w0.132: U34.F15 v1(155.16,96.99)
  BOTTOM w0.122: v1(155.16,96.99) 155.55,96.6 159.68,96.6 159.77,96.68
  BOTTOM w0.132: TP46.1 165.42,110.74 161.72,107.04 161.72,103.3 160.53,102.11 160.53,101.22 160.91,100.84 160.91,97.82 159.77,96.68
N17903256: length 1.9
  TOP w0.132: SW4.4 R302.2
N17903258: length 1.9
  TOP w0.132: SW4.3 R306.2
N17976903: length 2
  BOTTOM w0.132: R596.2 U95.7
N18001847: length 1.8
  BOTTOM w0.132: U114.1 R700.2
N18001866: length 1.6
  BOTTOM w0.132: R699.1 U114.3
N18022426: length 1.7
  TOP w0.132: R31.2 116.68,155.51 116.36,155.83 U6.5
N18022434: length 2.4
  TOP w0.132: U6.4 115.18,155.45 115.44,155.19 116.24,155.19 116.37,155.06 R35.1
N18024163: length 1.5
  TOP w0.132: U8.7 123.33,155.65 123.52,155.46 R30.1
N18024634: length 1.5
  TOP w0.132: R125.1 109.04,115.05 109.23,114.86 U23.7
N18046866: length 3.7
  TOP w0.132: U14.16 69.41,141.41 69,141.82 69,142.55 68.26,143.29 C51.1
N18046972: length 1.1
  TOP w0.132: R55.2 79.16,143.53 C49.1
N18070254: length 2.1
  BOTTOM w0.132: U95.13 146.54,62.41 R603.2
N18070257: length 1.9
  BOTTOM w0.132: U95.12 R602.2
N18070260: length 2.1
  BOTTOM w0.132: R601.2 146.54,63.41 U95.11
N18104656: length 2.2
  BOTTOM w0.254: R395.1 J8.1
N18104659: length 2.2
  BOTTOM w0.132: J8.3 R394.2
N18115017: length 47.3
  L12_SIG4 w0.084: J14.B12 21.45,91.77 34.6,91.77 35.69,90.68 35.69,88.77 33.53,86.61 23.62,86.61 20.57,83.57 16.26,83.57 15.37,84.45 15.37,87.88 v1(17.27,89.79)
  BOTTOM w0.132: R496.2 v1(17.27,89.79)
N18115328: length 18.3
  L03_SIG1 w0.084: v1(45.54,89.22) 46.23,88.53 46.23,81.97 v1(47.48,80.72)
  BOTTOM w0.132: TP56.1 45.56,89.25 v1(45.54,89.22) 48.79,89.22 49.07,88.95 U88.13 ; v1(47.48,80.72) 48.84,80.72 49.07,80.94 U88.48
N18116794: length 1.4
  BOTTOM w0.132: Q16.1 R512.2
N18116818: length 1.2
  BOTTOM w0.132: Q12.1 24.52,100.52 R467.1
N18116875: length 1.2
  BOTTOM w0.132: Q13.1 R468.1
N18117332: length 1.4
  BOTTOM w0.132: R515.2 Q15.1
N18117348: length 1.4
  BOTTOM w0.132: Q14.1 R495.1
N18117389: length 1.6
  TOP w0.132: Q5.1 R161.1
N18118509: length 18.1
  TOP w0.132: U34.AF14 v1(138.36,98.59)
  L10_SIG3 w0.084: v1(124.73,91.95) 126.92,94.14 126.92,94.49 127.19,94.75 130.41,94.75 132.68,97.03 133.92,97.03 135.87,98.98 137.96,98.98 v1(138.36,98.59)
  BOTTOM w0.132: R494.1 v1(124.73,91.95)
N18118513: length 21.8
  TOP w0.132: U34.AC15 v1(140.76,96.99)
  L10_SIG3 w0.084: v1(124.73,89.92) 125.19,90.37 125.19,91.82 127.11,93.74 127.62,93.74 127.63,93.73 130.01,93.73 130.98,94.7 134.14,94.7 134.42,94.98 134.42,95.39 135.61,96.58 138.5,96.58 138.76,96.85 138.76,97.15 138.99,97.38 140.36,97.38 v1(140.76,96.99)
  BOTTOM w0.132: R500.1 v1(124.73,89.92)
N18118517: length 11.3
  TOP w0.132: R211.1 v1(132.73,91.06) ; U34.AH16 v1(136.76,96.19)
  L03_SIG1 w0.084: v1(132.73,91.06) 131.76,91.06 131.57,91.25 131.57,94.02 132.15,94.6 133.74,94.6 135.08,95.94 136.06,95.94 136.31,96.19 v1(136.76,96.19)
N18118519: length 16.3
  TOP w0.132: RA4.6 v1(132.71,88.71) ; U34.AF16 v1(138.36,96.19)
  L03_SIG1 w0.084: v1(132.71,88.71) 131.69,89.73 131.69,90 131.99,90.31 133.03,90.31 133.27,90.55 133.27,91.27 133.03,91.52 132.04,91.52 131.89,91.67 131.89,93.26 132.04,93.41 134,93.41 135.74,95.15 135.86,95.15 136.49,95.78 137.95,95.78 v1(138.36,96.19)
N18118521: length 17.8
  TOP w0.132: U34.AG16 v1(137.56,96.19) ; v1(133.67,88.71) 133.35,88.4 133.35,88.4 133.03,88.08 RA4.5
  L03_SIG1 w0.084: v1(133.67,88.71) 133.21,88.26 132.52,88.26 131.23,89.54 131.23,94.29 133.52,96.58 137.16,96.58 v1(137.56,96.19)
N18118523: length 13.6
  TOP w0.132: v1(133.67,89.85) 133.03,89.21 RA4.7 ; U34.AE16 v1(139.16,96.19)
  L03_SIG1 w0.084: v1(139.16,96.19) 139.55,95.8 139.55,94.43 139.32,94.2 136.49,94.2 136.14,93.86 136.14,93.85 135.7,93.41 135.7,90.94 135.06,90.31 134.13,90.31 v1(133.67,89.85)
N18118537: length 15.1
  TOP w0.132: RA4.8 v1(132.71,89.85) ; U34.AD16 v1(139.96,96.19)
  L03_SIG1 w0.084: v1(139.96,96.19) 140.35,95.8 140.35,93.63 140.12,93.4 136.64,93.4 136.08,92.84 136.08,90.28 135.19,89.39 133.17,89.39 v1(132.71,89.85)
N18118541: length 12.8
  TOP w0.132: R209.1 v1(132.73,92.08) ; U34.AE17 v1(139.16,95.39)
  L03_SIG1 w0.084: v1(132.73,92.08) 132.73,92.69 132.88,92.84 134,92.84 134.22,92.62 134.22,91.76 134.38,91.6 135.19,91.6 135.39,91.81 135.39,92.38 135.24,92.53 135.04,92.53 134.89,92.69 134.89,92.99 135.04,93.14 135.24,93.14 135.39,93.3 135.39,93.96 136.43,95 138.76,95 v1(139.16,95.39)
N18122515: length 1.5
  TOP w0.132: Q3.1 R73.1
N18122533: length 1.2
  TOP w0.132: R72.1 Q4.1
N18122581: length 1.3
  BOTTOM w0.132: Q9.1 R451.1
N18125073: length 17.6
  TOP w0.132: U34.A27 v1(159.32,87.79)
  BOTTOM w0.122: 159.77,87.79 v1(159.32,87.79)
  BOTTOM w0.132: 159.77,87.79 161.78,87.79 164.97,84.6 169.99,84.6 170.82,83.77 170.82,81.32 171.24,80.9 TP60.1
N18125082: length 5.5
  TOP w0.132: R208.1 163.43,92.95 162.97,92.48 160.25,92.48 159.34,93.39 U34.A20
N18125186: length 7.2
  TOP w0.132: U34.AB2 v1(141.56,108.19) ; R129.1 v1(140.46,113.33)
  L03_SIG1 w0.084: v1(141.56,108.19) 141.96,108.6 141.96,111.83 v1(140.46,113.33)
N18184841: length 1.4
  BOTTOM w0.132: U110.18 R667.1
N18184861: length 2.2
  BOTTOM w0.132: U110.23 81.27,19.48 81.56,19.77 81.98,19.77 82.3,20.09 R660.2
N18184865: length 2.7
  BOTTOM w0.132: U110.24 81.77,19.03 82.17,19.43 82.99,19.43 83.31,19.75 R659.2
N18275385: length 2.5
  TOP w0.132: R218.1 90.25,83.16 90.82,83.74 U37.6
N18276744: length 1
  TOP w0.132: C214.1 95.49,74.06 R229.2
N18280417: length 1.7
  TOP w0.132: R233.2 U41.4
N18280437: length 1.7
  BOTTOM w0.132: R565.2 U92.4
N18280477: length 1.7
  BOTTOM w0.132: U90.4 R543.2
N18280857: length 1.7
  TOP w0.132: U39.4 R223.2
N18289329: length 85.3
  TOP w0.132: v1(115.06,51.65) 114.32,50.9 R300.1 U49.3
  L10_SIG3 w0.381: v1(115.06,51.65) 116.35,52.93 118.14,52.93 126.25,61.05 130.52,61.05 135.98,66.51 146.24,66.51 149.28,69.55 154.89,69.55 156.85,71.5 161.67,71.5 168.76,78.59 v1(172.88,78.59)
  BOTTOM w0.381: v1(172.88,78.59) 174.12,79.82 174.12,87.5 175.21,88.6 R476.2
N18289350: length 1.6
  TOP w0.132: U49.5 113.81,54.29 113.41,54.68 113.41,54.68 C232.1
N18289892: length 1.7
  BOTTOM w0.132: U112.3 R674.1
N18289915: length 1.9
  BOTTOM w0.132: R671.2 U112.1
N18292398: length 3.6
  TOP w0.132: R200.2 R201.1 C168.1 91.96,94.94 U35.3
N18320293: length 5.6
  TOP w0.132: R194.1 79.51,97.57 R192.1 80.27,97.76 80.34,97.68 C161.2 81.79,97.68 83.2,96.28 Y1.2
N18320301: length 5.6
  TOP w0.132: Y1.1 83.2,100.07 81.79,98.67 C156.2 80.34,98.67 80.27,98.59 R192.2 79.51,98.78 R191.1
N18321769: length 3.2
  TOP w0.132: R199.1 67.85,96.02 68.39,96.56 68.39,97.25 68.69,97.56 U32.31
N18436285: length 6.7
  TOP w0.132: LD18.1 20.13,80.45 20.82,79.77 v1(20.82,77.61)
  BOTTOM w0.132: Q17.3 21.94,77.16 21.48,77.61 v1(20.82,77.61)
N18436298: length 3.2
  TOP w0.132: R224.1 14.86,77.47 15.68,78.29 LD18.3
N18436321: length 1.7
  TOP w0.132: Q6.1 R225.1
N18436342: length 4.9
  TOP w0.132: Q6.3 19.43,76.58 18.48,77.53 LD18.2
N18436344: length 1.7
  BOTTOM w0.132: R548.1 Q17.1
N18436628: length 1.5
  BOTTOM w0.132: R464.1 Q11.1
N18436656: length 1.6
  TOP w0.132: R177.1 LD17.2
N18436666: length 2.6
  TOP w0.132: LD17.1 64.39,104.57 64.39,104.58 v1(64.44,104.58)
  BOTTOM w0.132: v1(64.44,104.58) 63.73,104.58 Q11.3
N18436681: length 1.3
  BOTTOM w0.132: Q10.1 R458.1
N18436707: length 1.7
  TOP w0.132: LD16.2 72.49,106.39 R155.1
N18546005: length 53.4
  TOP w0.132: R5.1 17.14,170.63 17.01,170.5 v1(16.26,170.5)
  L10_SIG3 w0.084: v1(62.32,162.28) 60.13,160.08 31.94,160.08 21.53,170.5 v1(16.26,170.5)
N18546027: length 3.3
  TOP w0.132: LD1.1 19.51,174.14 18.92,174.73 R5.2
N18546044: length 4.5
  TOP w0.132: LD1.2 19.51,170.79 18.73,170.02 D1.1
N18547174: length 1.3
  BOTTOM w0.132: R338.2 U62.5
N18547348: length 6.2
  BOTTOM w0.132: SW1.2 68.64,169.1 67.62,170.13 R337.2 65.6,170.24 U62.2
N18550089: length 2.3
  TOP w0.132: v1(166.04,168.4) 166.32,168.68 166.89,168.68 167.01,168.79 C3.1
  BOTTOM w0.132: U63.9 v1(166.04,168.4)
N18860929: length 1.8
  BOTTOM w0.132: R672.1 204.04,159.26 204.33,158.97 U109.10
N18860951: length 1.6
  BOTTOM w0.132: U109.2 203.9,160.07 R673.1
N18867275: length 1.4
  BOTTOM w0.132: R642.2 U105.21
N18867277: length 3.5
  BOTTOM w0.132: R635.2 141.27,42.56 140.77,42.06 U105.20
N18867279: length 1.4
  BOTTOM w0.132: U105.19 R643.2
N18867281: length 3.5
  BOTTOM w0.132: U105.18 139.77,42.06 140.27,42.56 R636.2
N18867283: length 1.4
  BOTTOM w0.132: U105.17 R644.2
N18867285: length 3.5
  BOTTOM w0.132: U105.16 138.77,42.06 139.27,42.56 R637.2
N18867287: length 3.5
  BOTTOM w0.132: R638.2 137.77,42.56 138.27,42.06 U105.15
N18867289: length 1.4
  BOTTOM w0.132: U105.14 R645.2
N18867885: length 1.4
  BOTTOM w0.132: R631.2 U102.21
N18867903: length 3.9
  BOTTOM w0.132: R626.2 126.03,48.97 125.53,48.47 U102.20
N18867905: length 1.4
  BOTTOM w0.132: U102.19 R632.2
N18867915: length 3.9
  BOTTOM w0.132: R627.2 125.03,48.97 124.53,48.47 U102.18
N18867925: length 1.4
  BOTTOM w0.132: U102.17 R633.2
N18867943: length 4
  BOTTOM w0.132: U102.16 123.53,46.27 123.38,46.42 123.38,48.32 124.03,48.97 R628.2
N18867953: length 3.9
  BOTTOM w0.132: U102.15 123.03,48.48 R629.2
N18867955: length 1.4
  BOTTOM w0.132: U102.14 R634.2
N18948512: length 3.4
  TOP w0.132: U24.D4 99.33,115.49 R124.1
N18950218: length 15.7
  TOP w0.132: U34.R4 v1(147.16,106.59)
  L12_SIG4 w0.084: v1(147.16,106.59) 147.16,106.66 146.78,107.04 146.78,108.36 146.99,108.58 147.28,108.58 147.53,108.83 147.53,109.17 147.22,109.48 147.22,113.88 148.86,115.52 v1(148.86,119)
  BOTTOM w0.132: R429.1 148.73,119.72 148.86,119.6 v1(148.86,119)
N18968753: length 2
  TOP w0.132: C42.1 U11.2
N18968782: length 1.7
  TOP w0.132: U11.5 R37.2
N18972035: length 1.7
  TOP w0.132: U26.15 R176.1
N18977103: length 1.3
  TOP w0.132: R77.2 LD7.2
N18977129: length 6.2
  BOTTOM w0.132: Y2.2 16.94,135.63 18.19,134.38 C337.1 19.23,134.38 19.81,134.97 19.81,135.7 20.3,136.19 U73.3
N18977189: length 7.2
  BOTTOM w0.132: Y2.1 16.94,131.83 18.19,133.08 C344.1 19.74,133.08 20.08,133.42 20.08,135.45 20.31,135.69 U73.2
N18977240: length 19.4
  TOP w0.132: LD7.1 9.26,131.24 v1(9.08,131.06)
  L05_SIG2 w0.084: v1(9.08,131.06) 10.42,132.4 23.03,132.4 v1(25.05,134.42)
  BOTTOM w0.132: U73.60 v1(25.05,134.42)
N19031494: length 1.5
  TOP w0.132: U40.9 v1(31.9,76.57)
  BOTTOM w0.132: C601.1 31.61,76.29 v1(31.9,76.57)
N19031660: length 1.2
  BOTTOM w0.132: C264.1 113.61,168.05 U64.9
N19158110: length 1.7
  TOP w0.132: U50.4 107.04,50.96 R299.1
N19311007: length 7.6
  TOP w0.132: U34.A11 159.16,100.99 161.38,100.99 162.31,101.92 162.31,103.61 163.09,104.39 R165.2
N19311901: length 85
  L03_SIG1 w0.084: v1(113.09,137.6) 112.83,137.34 112.83,132.31 111.61,131.09 111.61,127.83 111.04,127.26 111.04,125.97 114.54,122.47 116.61,122.47 119.43,119.65 119.43,106.5 118.75,105.82 118.75,104.89 v1(122.54,101.09)
  L05_SIG2 w0.084: v1(145.63,139.19) 145.17,139.19 145.05,139.06 114.55,139.06 v1(113.09,137.6)
  BOTTOM w0.132: R469.1 v1(122.54,101.09) ; D16.3 146.32,146.08 R380.2 146.32,142.06 145.99,141.73 145.99,139.55 v1(145.63,139.19)
N19312123: length 2.3
  TOP w0.132: R25.2 R28.1 D4.3
N19753713: length 8.7
  BOTTOM w0.254: D17.1 94.62,133.6 95.39,132.83 C343.2 U75.11
N19753729: length 5.7
  BOTTOM w0.132: 97.73,130.37 98.73,130.37 100.76,132.39 C343.1 100.95,133.02 U75.10
N19753760: length 3
  BOTTOM w0.254: 86.67,117.61 R703.1 86.67,119.56 86.92,119.81 R426.1
N19753772: length 20
  L10_SIG3 w0.203: v1(86.57,129.78) 86.98,129.78 87.25,130.05 v1(101.2,130.05)
  BOTTOM w0.132: U75.8 101.95,132.43 101.38,131.86 R405.2 101.38,130.23 v1(101.2,130.05)
  BOTTOM w0.254: U78.4 v1(86.57,129.78)
N19753820: length 25.7
  TOP w0.254: v1(82.17,125.73) 82.99,126.56 R392.1
  L12_SIG4 w0.254: v1(98.93,135.87) 98.44,135.38 97.35,135.38 90.41,128.45 84.04,128.45 82.68,127.08 82.68,126.24 v1(82.17,125.73)
  BOTTOM w0.254: U75.13 v1(98.93,135.87)
N19753822: length 6.2
  TOP w0.254: R396.2 84.26,130.95 v1(83.6,131.62) 82.99,131.01 R392.2
  BOTTOM w0.254: U81.4 v1(83.6,131.62)
N19753872: length 33.2
  L12_SIG4 w0.254: v1(104.37,132.36) 103.89,131.87 103.89,127.76 97.16,121.03 89.43,121.03 86.39,117.98 86.39,115.54 v1(86.74,115.19)
  BOTTOM w0.132: v1(104.37,132.36) 103.95,132.78 U75.4
  BOTTOM w0.254: R703.2 86.51,116.85 C684.1 86.51,115.42 v1(86.74,115.19)
N19753878: length 33
  L12_SIG4 w0.254: v1(85.72,115.19) 85.98,115.44 85.98,118.15 89.27,121.44 96.99,121.44 103.48,127.93 103.48,131.91 v1(103.03,132.36)
  BOTTOM w0.132: v1(103.03,132.36) 103.45,132.78 U75.5
  BOTTOM w0.254: R704.2 85.95,116.47 C684.2 85.95,115.42 v1(85.72,115.19)
N19753964: length 1.1
  BOTTOM w0.132: C352.1 104.27,130.83 104.23,130.87 R399.1
N19754006: length 1.6
  BOTTOM w0.132: C317.1 106.05,140.98 105.45,140.39 U75.30
N19754185: length 1.5
  BOTTOM w0.132: C345.1 105.99,132.86 105.45,133.4 U75.1
N19754201: length 10.5
  BOTTOM w0.132: U75.21 100.95,141.09 100.5,141.54 C320.2 100.48,142.34 99.76,143.07 94.44,143.07 94.23,143.27 L8.2
N19754203: length 8.4
  BOTTOM w0.254: D15.1 95.51,141.35 95.69,141.54 C320.1 99.92,140.49 100.2,140.21 U75.20
N19754223: length 1.5
  BOTTOM w0.132: U75.22 101.45,140.81 101.41,140.85 R378.2
N19754237: length 18.4
  L05_SIG2 w0.203: v1(89.28,142.75) 90.13,143.6 101.13,143.6 v1(102.23,142.49)
  BOTTOM w0.132: U75.23 101.95,141.83 102.23,142.11 v1(102.23,142.49) 101.43,142.49 R378.1
  BOTTOM w0.254: U72.4 89.09,143.44 89.28,143.26 v1(89.28,142.75)
N19754314: length 4.5
  TOP w0.254: R384.1 81.57,142.63 v1(80.99,142.04) 81.54,141.49 82,141.49 82.13,141.36 R387.1
  BOTTOM w0.254: U71.4 81.06,142.12 v1(80.99,142.04)
N19754320: length 19
  TOP w0.254: v1(84.33,143.04) 84.33,143.04 84.33,142.76 84.19,142.63 R384.2
  L12_SIG4 w0.254: v1(99.19,139.45) 98.68,139.45 98.55,139.32 97.09,139.32 95.41,141.01 89.66,141.01 88.14,142.53 84.83,142.53 v1(84.33,143.04)
  BOTTOM w0.254: U75.19 99.51,138.87 99.19,139.19 v1(99.19,139.45)
N19754322: length 18.5
  TOP w0.254: v1(84.29,141.19) 84.12,141.36 R387.2
  L12_SIG4 w0.254: v1(99.06,138.43) 98.55,138.43 98.42,138.3 96.96,138.3 95.07,140.19 89.33,140.19 87.8,141.72 84.82,141.72 v1(84.29,141.19)
  BOTTOM w0.254: U75.18 99.12,138.37 v1(99.06,138.43)
N19754431: length 3.8
  BOTTOM w0.132: U75.9 101.45,132.57 100.55,131.66 R405.1
N19754435: length 24.5
  TOP w0.254: v1(84.71,125.73) 84.26,126.17 R396.1
  L12_SIG4 w0.254: v1(84.71,125.73) 83.95,126.49 83.95,127.2 84.38,127.64 90.82,127.64 97.6,134.42 v1(98.93,134.42)
  BOTTOM w0.254: U75.12 99.38,135.37 98.93,134.92 v1(98.93,134.42)
N19754522: length 3.1
  BOTTOM w0.254: R357.2 86.92,156.27 86.84,156.35 R701.1 86.84,158.47
N19754526: length 31.8
  L12_SIG4 w0.254: v1(103.41,141.35) 103.73,141.68 103.73,143.6 100.42,146.91 98.03,146.91 86.11,158.84 86.11,160.76 v1(85.83,161.04)
  BOTTOM w0.132: U75.26 103.45,140.81 103.41,140.85 v1(103.41,141.35)
  BOTTOM w0.254: R702.2 86.05,159.54 C683.1 86.05,160.81 v1(85.83,161.04)
N19754534: length 32.1
  L12_SIG4 w0.254: v1(86.74,161.04) 86.51,160.81 86.51,159 98.2,147.32 100.58,147.32 104.14,143.76 104.14,141.47 v1(104.35,141.25)
  BOTTOM w0.132: v1(104.35,141.25) 103.95,140.85 U75.27
  BOTTOM w0.254: v1(86.74,161.04) 86.61,160.9 C683.2 86.61,159.31 R701.2
N19754630: length 1.6
  BOTTOM w0.132: C325.2 107.23,138.97 107.12,138.87 U75.32
N19754677: length 1.1
  BOTTOM w0.132: C307.1 106.45,144.11 R375.1
N20141585: length 2.9
  BOTTOM w0.132: U109.1 203.9,159.67 203.7,159.87 202.95,159.87 202.26,160.56 R680.1
N20142928: length 0.9
  TOP w0.254: C14.1 199.16,158.91 199.16,158.91 U5.2
N20155231: length 3.1
  BOTTOM w0.132: U45.6 189.05,57.07 188.85,57.28 188.85,57.78 189.27,58.2 R246.1
N20155262: length 4.4
  BOTTOM w0.132: R604.1 186.05,60.47 185.84,60.68 185.84,61.83 186.18,62.16 U96.6
N20584902: length 5.3
  BOTTOM w0.132: U77.B2 147.07,132.84 147.07,133.9 148.66,135.5 R706.2
N20753582: length 2
  BOTTOM w0.254: C303.2 R374.2 R373.2
N21124530: length 2.7
  BOTTOM w0.132: J38.33 R675.2
N21549383: length 88.5
  TOP w0.132: R729.1 146.46,140.33 v1(146.69,140.1) ; U34.F18 v1(155.16,94.59)
  L05_SIG2 w0.084: v1(176.02,115.8) 176.02,129.29 176.91,130.18 176.91,134.49 175.77,135.64 171.91,135.64 170.93,136.61 153.45,136.61 152.02,138.05 148.74,138.05 v1(146.69,140.1)
  L12_SIG4 w0.084: v1(155.16,94.59) 154.77,94.97 154.77,97.24 155.56,98.03 155.56,103.53 155.83,103.8 159.42,103.8 163.32,107.7 168.33,107.7 169.16,108.53 169.16,109.6 175.37,115.8 v1(176.02,115.8)
N22464359: length 3.7
  BOTTOM w0.132: U115.5 183.64,58.55 184.11,59.02 R736.2
N22573349: length 4
  BOTTOM w0.132: R745.2 143.03,136.72 U77.A5
N23068969: length 1.3
  TOP w0.132: SW9.6 R668.2
N23068970: length 1.3
  TOP w0.132: SW9.8 R88.2
N23068971: length 1.8
  TOP w0.132: SW9.5 115.75,135.71 114.6,135.71 114.43,135.53 R81.2
N23068972: length 1.3
  TOP w0.132: SW9.7 R441.2
N23079966: length 2.2
  BOTTOM w0.132: R762.2 156.63,169.34 R764.1 156.76,170.56 U60.2
N23093100: length 4.9
  BOTTOM w0.249: v1(127.69,173.86) 127.84,173.71 U61.C1 U61.C2 U61.C3 127.84,171.53
  BOTTOM w0.762: 127.84,171.53 127.84,170.94 128.6,170.18 L4.1
  vias: v1(127.84,171.7)
N23240225: length 2
  BOTTOM w0.132: R647.1 116.85,35.27 115.87,36.25 U125.6
N23474700: length 64.9
  TOP w0.132: v1(166.14,139.32) 165.13,140.34 162.74,140.34 161.65,141.43 159.53,141.43 159.35,141.24 R66.2 158.91,140.79 158.82,140.7 158.56,140.7 158.12,140.25 158.12,138.66 158.6,138.18 U17.2
  L10_SIG3 w0.084: J47.1 203.96,140.56 196.4,148.12 179.49,148.12 170.69,139.32 v1(166.14,139.32)
N23475552: length 2.2
  TOP w0.132: J47.2 206.5,135.08 R768.1
N23484157: length 3.9
  TOP w0.132: U32.24 70.13,101.85 69.77,102.21 69.09,102.21 68.83,102.46 R771.1 68.28,102.94 68.07,102.74 C717.1
N23484680: length 3.1
  TOP w0.132: U32.22 71.13,102.19 70.96,102.36 v1(70.96,102.36)
  BOTTOM w0.132: v1(70.96,102.36) 71.24,102.08 71.24,101.91 71.23,101.9 R772.1 70.24,101.48 C718.1
N23514459: length 5
  BOTTOM w0.132: U126.5 118.89,21.12 117.1,22.9 R778.1
N23544850: length 3.7
  BOTTOM w0.132: U121.5 180.95,51.84 181.74,51.05 R754.1
N23545101: length 2.5
  BOTTOM w0.132: R766.2 172.53,51.61 172.76,51.84 U121.4
N23728299: length 2.3
  BOTTOM w0.305: U119.9 44.31,150.02 44.32,150.04
N23729329: length 15.8
  TOP w0.132: TP92.1 v1(35.05,155.78)
  BOTTOM w0.132: U119.7 42.71,151.02 42.93,151.23 42.93,152.73 43.27,153.07 R757.1 43.69,154.91 42.82,155.78 v1(35.05,155.78)
N23730398: length 1.9
  BOTTOM w0.132: U119.3 39.1,150.52 38.37,151.26 R767.2
N23817015: length 3.5
  BOTTOM w0.132: U129.5 179.63,8.15 178.84,8.94 R783.1
N23817037: length 2.4
  BOTTOM w0.132: U129.4 187.82,8.15 188.05,8.38 R784.2
N23888383: length 8.6
  BOTTOM w0.132: R786.2 R476.1 175.21,96.85 173.75,98.31 R785.2
N23956430: length 1.7
  BOTTOM w0.132: C265.1 142.7,167.4 142.1,168 U130.12
N23956432: length 6.6
  TOP w0.132: C4.2 139.71,166.47 139.57,166.34 v1(139.57,165.85)
  BOTTOM w0.132: R340.1 141.1,167.74 U130.14 ; R340.1 140.31,167.36 140.14,167.2 140.14,166.62 140.05,166.52 R341.2 v1(139.57,165.85) ; R340.1 R339.2
N23956434: length 5.5
  TOP w0.132: v1(141.09,172.37) 141.09,170.87 139.89,169.67 R10.1
  BOTTOM w0.132: U130.6 141.1,172.37 v1(141.09,172.37)
