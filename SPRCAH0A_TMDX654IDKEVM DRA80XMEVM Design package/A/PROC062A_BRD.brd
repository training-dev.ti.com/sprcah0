# Allegro board PROC062A_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L05_SIG2 (solid shape): 29.78,140.3 29.87,140.24 29.85,140.13 29.65,139.93 29.65,138.56 30.48,137.73 33.2,137.73 33.27,137.7 33.3,137.62 33.68,137.21 34.06,137.62 34.09,137.7 34.16,137.73 44.75,137.73 45.81,136.67 45.83,136.55 45.74,136.49 30.22,136.49 29.41,135.69 29.4,135.69 29.26,135.58 29.18,135.42 29.1,135.34 29,135.37 28.9,135.47 28.9,135.48 28.28,135.6 28.4,134.98 28.41,134.98 28.45,134.94 28.48,134.85 28.41,134.78 28.17,134.42 28.4,134.07 28.41,134.06 28.83,133.64 28.86,133.53 28.76,133.47 28.12,133.47 27.27,134.32 27.27,136.52 26.39,137.4 26.36,137.47 26.4,137.54 26.42,138.1 25.86,138.08 25.79,138.05 25.71,138.08 23.66,140.13 23.64,140.24 23.73,140.3
DGND on L05_SIG2 (solid shape): outline of 198 points within 171.44,49.52 180.53,63.15
DGND on L05_SIG2 (solid shape): outline of 195 points within 159.35,31.15 162.66,39.49
DGND on L05_SIG2 (solid shape): outline of 191 points within 151.91,85.38 154.66,89.04
DGND on L05_SIG2 (solid shape): outline of 199 points within 170.04,95.84 172.03,100.49
DGND on L05_SIG2 (solid shape): outline of 128 points within 68.81,99.3 88.62,100.44
DGND on L05_SIG2 (solid shape): outline of 256 points within 165.22,50.87 170.44,63.93
DGND on L05_SIG2 (solid shape): outline of 288 points within 54.77,96.29 63.74,104.63
DGND on L05_SIG2 (solid shape): outline of 305 points within 62.9,101.74 72.56,107.22
DGND on L05_SIG2 (solid shape): outline of 300 points within 113.78,113.62 132.35,118.79
DGND on L05_SIG2 (solid shape): outline of 341 points within 56.05,100.82 66.68,106.27
DGND on L05_SIG2 (solid shape): outline of 356 points within 109.95,109.69 117.18,117.9
DGND on L05_SIG2 (solid shape): outline of 391 points within 94.15,100.44 111.01,107.86
DGND on L05_SIG2 (solid shape): outline of 406 points within 89.05,91.2 109,96.74
DGND on L05_SIG2 (solid shape): outline of 552 points within 179.36,48.53 190.41,61.41
DGND on L05_SIG2 (solid shape): outline of 546 points within 153.16,87.51 165.72,92.29
DGND on L05_SIG2 (solid shape): outline of 597 points within 141.18,40.94 161.16,46.84
DGND on L05_SIG2 (solid shape): outline of 662 points within 141.51,89.1 144.02,97.16
DGND on L05_SIG2 (solid shape): outline of 734 points within 153.86,60.28 171.41,79.77
DGND on L05_SIG2 (solid shape): outline of 1268 points within 84.57,13.59 162.19,32.72
DGND on L05_SIG2 (solid shape): outline of 1339 points within 85.11,96.32 120.05,118.99
DGND on L05_SIG2 (solid shape): outline of 1471 points within 121.5,27.91 162.28,44.88
DGND on L05_SIG2 (solid shape): outline of 1658 points within 67.28,106.46 112.6,123.94
DGND on L05_SIG2 (solid shape): outline of 2023 points within 102.01,117.16 149.56,137.63
DGND on L05_SIG2 (solid shape): outline of 2109 points within 92.38,44.68 165.15,58.39
DGND on L05_SIG2 (solid shape): outline of 2910 points within 140.7,94.2 156,108.08
DGND on L05_SIG2 (solid shape): outline of 7178 points within 14.57,53.98 141.11,111.41
DGND on L05_SIG2 (solid shape): outline of 14781 points within 111.66,55.13 200.94,158.3
DGND on L05_SIG2 (solid shape): outline of 50411 points within 7.51,0.52 209.66,177.28
DGND on L10_SIG3 (solid shape): 171.39,102.36 169.35,102.36 169.35,103.17 169.34,103.19 169.36,103.25 171.39,103.25
DGND on L10_SIG3 (solid shape): 137.26,114.92 137.28,114.81 137.18,114.75 134.09,114.75 134.07,114.82 134.04,114.88 134.45,115.29 136.89,115.29
DGND on L10_SIG3 (solid shape): 88.55,111.61 88.6,111.57 74.28,97.25 74.05,97.25 73.95,97.31 73.98,97.42 88.19,111.64 88.47,111.64
DGND on L10_SIG3 (solid shape): 37.99,117.93 38.05,118.02 38.16,118 38.31,117.85 38.31,113.23 38.25,113.14 38.14,113.16 37.99,113.31
DGND on L10_SIG3 (solid shape): 80.82,43.73 80.93,43.75 81,43.65 81,43.31 77.43,39.75 77.09,39.75 77,39.81 77.02,39.92
DGND on L10_SIG3 (solid shape): 85.94,86.8 85.98,86.77 85.97,86.71 85.94,86.68 85.94,85.55 84.47,85.55 84.47,86.4 84.25,86.62 84.23,86.74 84.32,86.8
DGND on L10_SIG3 (solid shape): 142.24,116.04 142.26,115.93 142.16,115.87 139.59,115.87 139.31,116.14 139.29,116.25 139.39,116.32 141.96,116.32
DGND on L10_SIG3 (solid shape): 150.42,149.5 150.51,149.44 150.49,149.33 146.95,145.79 146.84,145.77 146.78,145.86 146.78,146.03 150.25,149.5
DGND on L10_SIG3 (solid shape): 180.2,127.87 180.25,127.84 180.24,127.78 179.11,126.66 177.67,126.66 177.58,126.72 177.6,126.83 177.71,126.94 179.24,126.94 180.17,127.87
DGND on L10_SIG3 (solid shape): 39.01,117.94 39.07,118.04 39.18,118.01 39.35,117.84 39.35,114.33 41.01,112.67 41.04,112.56 40.94,112.5 39.81,112.5 39.01,113.31
DGND on L10_SIG3 (solid shape): 83.25,65.57 83.34,65.5 83.32,65.39 79.62,61.69 75.57,61.69 75.42,61.84 75.4,61.95 75.49,62.01 79.19,62.01 82.75,65.57
DGND on L10_SIG3 (solid shape): 139.1,115.38 139.12,115.27 139.02,115.2 137.95,115.2 137.18,115.98 135.19,115.98 135.1,116.04 135.12,116.15 135.34,116.37 138.11,116.37
DGND on L10_SIG3 (solid shape): 187.19,89.42 187.31,89.34 187.45,89.31 187.63,89.31 187.63,89.14 187.16,88.67 186.51,88.67 186.51,89.41 186.55,89.5 186.65,89.51 186.84,89.47 187.02,89.53 187.06,89.56
DGND on L10_SIG3 (solid shape): 191.84,104.55 191.86,104.44 191.76,104.38 190.61,104.38 190.47,104.35 190.35,104.27 190.17,104.09 189.89,104.38 189.19,104.38 189.15,104.42 189.13,104.53 189.22,104.6 191.79,104.6
DGND on L10_SIG3 (solid shape): 46.87,123.06 46.97,123 46.94,122.89 46.81,122.75 46.81,120.58 46.46,120.58 46.46,122.27 45.99,122.73 45.21,122.73 44.75,122.27 44.75,120.58 44.43,120.58 44.43,122.37 44.07,122.72 43.49,122.72 43.4,122.78 43.42,122.9 43.58,123.06
DGND on L10_SIG3 (solid shape): 169.69,97.13 169.7,97.13 169.77,97.1 169.8,97.02 169.8,96.98 169.77,96.91 169.7,96.88 167.35,96.88 167.35,97.82 167.18,98 167.15,98.11 167.25,98.17 168.65,98.17
DGND on L10_SIG3 (solid shape): 177.64,100.64 177.75,100.67 177.81,100.57 177.81,99.4 177.57,99.16 174.36,99.16 174.36,99.27 174.36,99.3 174.35,99.36 174.61,99.62 174.66,99.67 174.84,99.49 174.96,99.42 175.1,99.39 177.21,99.39 177.55,99.72 177.55,100.55
DGND on L10_SIG3 (solid shape): 108.18,118.79 108.22,118.83 108.27,118.82 109.07,118.02 109.79,118.02 110.13,118.36 110.37,118.13 110.48,118.05 110.61,118.02 111.12,118.02 111.19,118 111.23,117.93 111.23,117.82 108.9,117.82 108.1,118.63 108.18,118.71
DGND on L10_SIG3 (solid shape): 129.2,114.66 129.22,114.55 129.13,114.49 128.79,114.49 128.32,114.01 126.64,114.01 125.99,114.66 125.83,114.66 125.75,114.7 125.73,114.78 125.74,114.83 125.74,114.89 125.77,114.96 125.84,114.99 128.86,114.99
DGND on L10_SIG3 (solid shape): 108.61,90.68 108.71,90.62 108.68,90.51 104.53,86.36 92.69,86.36 92.6,86.41 92.6,86.51 92.64,86.6 92.65,86.69 92.68,86.77 92.75,86.8 102.08,86.8 105.97,90.68
DGND on L10_SIG3 (solid shape): 56.17,91.83 56.26,91.77 56.24,91.66 54.34,89.75 54.25,89.72 54.18,89.77 54.05,89.91 53.88,89.97 53.81,90 53.78,90.07 53.78,90.57 55.05,91.83
DGND on L10_SIG3 (solid shape): 136.38,103.95 136.45,103.98 136.53,103.95 136.61,103.89 136.71,103.86 136.79,103.79 136.77,103.69 135.66,102.58 133.67,102.58 133.58,102.64 133.6,102.76 134.35,103.51 135.94,103.51
DGND on L10_SIG3 (solid shape): 50.04,78.18 50.15,77.89 50.46,77.78 50.53,77.76 50.57,77.68 50.57,75.37 51.09,74.85 51.09,73.25 51.03,73.15 50.91,73.18 49.92,74.17 49.92,78.24 50.04,78.24
DGND on L10_SIG3 (solid shape): 114.19,117.57 114.25,117.67 114.36,117.64 115.07,116.94 117.37,116.94 117.46,116.89 117.46,116.79 117.45,116.5 117.64,116.29 117.65,116.29 117.69,116.24 117.66,116.21 117.66,115.7 118.37,114.99 118.23,114.84 115.66,114.84 114.19,116.31
DGND on L10_SIG3 (solid shape): 147.74,104.12 147.74,103.37 148.43,102.67 148.43,102.63 148.36,102.55 148.26,102.57 147.73,103.1 147.54,103.1 147.46,103.15 147.45,103.24 147.4,103.61 147.04,103.7 146.95,103.71 146.9,103.8 146.9,104.24 147.62,104.24
DGND on L10_SIG3 (solid shape): 41.97,126.12 42.05,126.07 42.05,125.97 42,125.83 42.01,125.69 41.99,125.61 41.91,125.57 41.24,125.57 37.85,122.19 37.85,120.77 37.79,120.68 37.68,120.7 37.55,120.8 37.39,120.82 37.32,120.85 37.29,120.93 37.29,122.49 40.92,126.12
DGND on L10_SIG3 (solid shape): 120.79,123.83 121.04,123.57 121.16,123.5 121.29,123.47 121.79,123.47 122.13,123.81 122.37,123.57 122.48,123.5 122.61,123.47 123.11,123.47 123.47,123.83 123.47,124.56 124.04,124.56 126.17,122.43 126.19,122.32 126.1,122.25 125.22,122.25 124.76,122.71 120.3,122.71 120.3,123.46 120.22,123.55 120.19,123.66 120.29,123.72 120.44,123.72 120.49,123.72 120.54,123.77 120.25,124.07 120.25,124.56 120.79,124.56
DGND on L10_SIG3 (solid shape): 130.9,118.75 132.23,118.75 132.3,118.73 132.34,118.66 132.34,118.58 132.27,118.58 132.14,118.56 132.03,118.48 131.94,118.4 131.83,118.51 131.72,118.58 131.59,118.61 131.23,118.61 130.77,118.16 130.77,117.65 130.79,117.64 130.81,117.53 130.72,117.47 128.98,117.47 128.89,117.53 128.91,117.64 129.11,117.84 129.11,119.78 129.88,119.78
DGND on L10_SIG3 (solid shape): 145.03,80.93 145.09,81.02 145.2,81 145.26,80.96 145.34,80.92 145.96,80.3 148.06,80.3 148.09,80.28 148.11,80.17 148.02,80.1 145.94,80.1 145.83,80.22 145.82,80.23 145.5,80.47 145.14,80.28 145.1,80.26 145.06,80.27 145.03,80.3
DGND on L10_SIG3 (solid shape): 60.87,82.14 60.91,82.08 61.07,81.74 61.44,81.7 61.45,81.7 62.78,81.7 62.87,81.64 62.85,81.53 61.55,80.23 60.85,80.23 60.78,80.26 60.75,80.33 60.74,80.37 60.72,80.4 60.56,80.56 60.56,81.81 60.78,82.03 60.8,82.06 60.81,82.09
DGND on L10_SIG3 (solid shape): 181.76,123.98 181.78,123.96 181.82,123.94 181.86,123.86 181.83,123.78 181.75,123.7 181.68,123.59 181.64,123.46 181.64,123.42 181.54,123.42 181.54,123.46 181.21,123.77 180.88,123.46 180.88,123.42 178.48,123.42 178.39,123.48 178.41,123.59 178.97,124.15 181.59,124.15
DGND on L10_SIG3 (solid shape): 51.64,93.11 51.73,93.05 51.71,92.94 51.62,92.68 51.74,92.42 51.77,92.35 51.74,92.28 51.5,92.04 50.85,92.04 49.5,90.7 49.42,90.67 49.34,90.71 49.02,90.89 48.7,90.71 48.69,90.69 48.61,90.69 48.61,90.86 50.86,93.11
DGND on L10_SIG3 (solid shape): 110.52,61.9 110.59,61.87 110.62,61.79 111,61.4 111.38,61.79 111.41,61.87 111.48,61.9 115.23,61.9 115.33,61.83 115.3,61.72 114.25,60.67 103.47,60.67 103.37,60.73 103.39,60.85 104.44,61.9
DGND on L10_SIG3 (solid shape): 140.16,133.49 140.16,127.6 139.48,126.92 139.37,126.9 139.31,126.99 139.31,129.21 139.34,129.29 139.43,129.31 139.88,129.68 139.43,130.06 139.34,130.08 139.31,130.16 139.31,133.4 133.36,139.35 133.34,139.46 133.43,139.52 134.12,139.52
DGND on L10_SIG3 (solid shape): 135.9,106.8 135.91,106.74 135.86,106.71 133.9,106.71 131.58,104.39 125.84,104.39 125.75,104.43 125.75,104.53 125.41,105.09 125.08,104.53 125.07,104.43 124.99,104.39 124.64,104.39 124.54,104.45 124.57,104.56 126.9,106.89 135.8,106.89
DGND on L10_SIG3 (solid shape): 107.06,115.36 107.14,115.34 107.19,115.28 107.19,115.28 107.34,115.13 107.36,115.04 107.3,114.97 107.23,114.93 107.17,114.89 106.92,114.63 106.92,114.13 106.94,114 107.02,113.89 107.18,113.73 107.21,113.65 107.18,113.58 106.92,113.31 106.92,112.67 107.27,112.31 107.44,112.31 107.44,111.74 107.38,111.64 107.26,111.67 106.52,112.41 106.52,115.09 106.55,115.17 106.64,115.19 106.83,115.21 106.99,115.33
DGND on L10_SIG3 (solid shape): 131.18,123.34 131.21,123.23 131.11,123.17 129.96,123.17 125.34,127.79 122.92,127.79 122.82,127.86 122.86,127.97 123.06,128.45 122.76,128.88 122.71,128.97 122.76,129.06 123.02,129.33 123.04,129.7 123.06,129.79 123.14,129.83 124.7,129.83
DGND on L10_SIG3 (solid shape): 150.03,105.11 150.02,105.08 150.02,104.9 150.11,104.74 150.22,104.64 150.25,104.55 150.19,104.48 150.07,104.36 150.03,104.2 150.02,104.15 149.09,104.15 149.09,104.2 148.99,104.42 148.73,104.54 148.71,104.57 148.71,105.05 149.13,105.05 149.19,105.03 149.23,104.96 149.6,104.66 149.88,105.04 149.88,105.07 149.97,105.16
DGND on L10_SIG3 (solid shape): 118.11,126.11 118.47,125.76 119.11,125.76 119.45,126.09 119.79,125.76 120.43,125.76 120.77,126.09 121.11,125.76 121.75,125.76 122.11,126.11 122.11,127.1 125.05,127.1 129.27,122.88 129.29,122.77 129.19,122.71 126.86,122.71 124.32,125.25 123.27,125.25 123.14,125.22 123.03,125.15 122.79,124.91 122.45,125.25 121.95,125.25 121.82,125.22 121.7,125.15 121.47,124.91 121.13,125.25 117.27,125.25 117.17,125.31 117.19,125.42 117.48,126.17 117.19,126.93 117.17,127.04 117.27,127.1 118.11,127.1
DGND on L10_SIG3 (solid shape): 155.64,106.63 156.39,106.63 156.39,106.31 156.41,106.17 156.49,106.05 156.5,106.02 156.49,105.99 156.43,105.86 156.43,105.72 156.44,105.69 156.38,105.64 156.28,105.74 156.28,105.76 155.97,106.12 155.63,105.8 155.62,105.75 155.49,105.75 155.49,105.8 155.37,106.04 155.12,106.12 155.1,106.12 155.05,106.17 155.14,106.26 155.16,106.26 155.41,106.38 155.48,106.66 155.47,106.69 155.53,106.74
DGND on L10_SIG3 (solid shape): 48.88,119.38 49.07,119.19 49.09,119.08 49,119.02 46.98,119.02 46.31,118.36 46.27,118.31 46.21,118.26 46.14,118.28 46.11,118.29 46.08,118.29 44.24,118.29 44.21,118.29 44.19,118.28 44.11,118.26 44.05,118.31 44.01,118.36 43.79,118.58 43.76,118.68 43.84,118.75 44.1,118.95 44.11,119.29 44.12,119.38 44.2,119.43 44.27,119.43 44.27,119.14 44.63,118.78 45.27,118.78 45.63,119.14 45.63,119.43 47.6,119.43 47.97,119.79 47.97,121.01 47.98,121.02 48.88,121.02
DGND on L10_SIG3 (solid shape): 95.16,89.19 95.27,89.08 95.3,89.01 95.27,88.93 95.26,88.92 95.22,88.9 95.18,88.93 95.14,88.97 94.89,89.23 94.24,89.23 94.1,89.08 93.98,89.06 93.92,89.15 93.92,89.36 93.57,89.71 93.07,89.71 92.93,89.69 92.82,89.61 92.57,89.36 92.57,88.45 92.49,88.45 92.42,88.48 92.39,88.55 92.01,88.94 91.63,88.55 91.6,88.48 91.53,88.45 91.5,88.45 90.27,89.68 90.24,89.79 90.34,89.85 95.16,89.85
DGND on L10_SIG3 (solid shape): outline of 91 points within 118.9,114.39 122.51,117.11
DGND on L10_SIG3 (solid shape): 141.1,99.22 141.18,99.17 141.21,99.13 141.25,99.08 141.74,98.59 141.12,97.97 141.12,97.23 141.03,97.2 141,97.24 140.51,97.73 139.42,97.73 139.33,97.79 139.35,97.9 139.5,98.06 139.5,98.31 139.56,98.4 139.68,98.38 139.71,98.34 140,98.25 140.33,98.47 140.42,98.44 140.51,98.34 141,98.34 141,98.84 140.89,98.94 140.87,99.03 140.92,99.1 140.97,99.14 141.01,99.19
DGND on L10_SIG3 (solid shape): 106.26,54.99 106.34,54.96 106.36,54.88 106.74,54.48 107.12,54.88 107.15,54.96 107.23,54.99 114.57,54.99 114.67,54.93 114.65,54.82 114.02,54.19 112.51,54.19 112.44,54.23 112.41,54.31 112.03,54.74 111.66,54.31 111.63,54.23 111.56,54.19 104.48,54.19 104.38,54.26 104.41,54.37 105.03,54.99
DGND on L10_SIG3 (solid shape): 180.88,129.01 180.98,128.8 181.21,128.71 181.22,128.71 181.44,128.8 181.54,129.01 181.54,129.06 182.07,129.06 182.16,129 182.14,128.89 182.05,128.8 182.05,128.62 182.04,128.58 182,128.57 181.84,128.52 181.72,128.4 181.63,128.34 181.54,128.4 181.41,128.55 181.22,128.61 181.21,128.61 181.07,128.58 180.95,128.5 180.88,128.42 180.79,128.39 180.72,128.44 180.59,128.56 180.41,128.61 179.87,128.61 178.93,127.67 177.77,127.67 177.68,127.74 177.7,127.85 178.92,129.06 180.88,129.06
DGND on L10_SIG3 (solid shape): 119.87,122.12 119.98,122.04 120.11,122.02 124.48,122.02 124.93,121.56 140.97,121.56 141.37,121.16 141.82,121.16 141.84,121.16 141.9,121.15 141.95,121.1 142.3,120.85 142.66,121.1 142.7,121.15 142.77,121.16 142.79,121.16 148.47,121.16 148.89,120.74 150.98,120.74 151.03,120.7 151.02,120.65 150.99,120.62 139.6,120.62 139.12,121.1 120.33,121.1 119.4,120.17 117.27,120.17 117.17,120.23 117.19,120.34 117.48,121.09 117.19,121.85 117.17,121.96 117.27,122.02 117.97,122.02 118.31,122.36 118.54,122.12 118.66,122.04 118.79,122.02 119.29,122.02 119.63,122.36
DGND on L10_SIG3 (solid shape): 187.2,93.64 187.07,93.52 186.99,93.4 186.96,93.26 186.96,92.97 186.99,92.83 187.07,92.71 187.2,92.59 187.07,92.46 186.99,92.34 186.96,92.2 186.96,91.92 186.99,91.78 187.07,91.66 187.2,91.53 187.07,91.4 186.99,91.29 186.96,91.14 186.96,90.86 186.99,90.72 187.07,90.6 187.2,90.47 187.07,90.35 187.03,90.3 187,90.24 186.97,90.21 186.93,90.21 186.79,90.23 186.65,90.2 186.55,90.2 186.51,90.29 186.51,92.41 186.48,92.55 186.4,92.67 186.31,92.77 186.43,92.9 186.51,93.01 186.54,93.16 186.54,93.44 186.54,93.48 186.54,93.51 186.57,93.61 186.67,93.62 186.88,93.61 187.07,93.7 187.1,93.74
DGND on L10_SIG3 (solid shape): 95.94,61.1 96.03,61.04 96.01,60.93 94.8,59.72 90.46,59.72 90.37,59.77 90.38,59.87 90.05,60.46 89.73,59.87 89.73,59.77 89.64,59.72 85.19,59.72 85.12,59.75 85.09,59.83 85.09,59.88 85.08,59.92 85.11,60.01 85.18,60.04 88.85,60.04 89.59,60.78 89.67,60.81 89.74,60.77 90.17,60.63 90.43,61 90.46,61.07 90.54,61.1
DGND on L10_SIG3 (solid shape): 148.58,54.61 148.62,54.52 148.62,54.47 153.59,49.5 156,49.5 157.13,48.37 157.13,44.96 157.07,44.87 156.96,44.89 156.94,44.91 156.94,48.15 156.23,48.86 154.05,48.86 153.98,48.89 153.95,48.96 153.57,49.33 153.19,48.96 153.16,48.89 153.09,48.86 152.86,48.86 149.17,52.55 149.17,53.49 148.23,53.49 148.17,53.55 148.17,53.57 148.21,53.65 148.29,53.67 148.71,54.05 148.29,54.43 148.21,54.46 148.17,54.53 148.17,54.6 148.24,54.6 148.36,54.59 148.48,54.62
DGND on L10_SIG3 (solid shape): outline of 103 points within 104.88,69.97 124.49,78.46
DGND on L10_SIG3 (solid shape): outline of 119 points within 100.27,76.04 115.07,87.51
DGND on L10_SIG3 (solid shape): 109.14,87.53 109.25,87.55 109.32,87.47 109.35,87.34 109.43,87.23 109.46,87.16 109.43,87.09 104.41,82.07 100.11,82.07 100.01,82.15 100.06,82.26 99.57,84.16 99.07,82.26 99.12,82.15 99.02,82.07 90.44,82.07 90.36,82.11 90.34,82.2 90.35,82.42 90.24,82.6 90.21,82.71 90.31,82.77 97.44,82.77 99.17,84.5 106.12,84.5
DGND on L10_SIG3 (solid shape): outline of 126 points within 52.04,60.3 68.81,63.1
DGND on L10_SIG3 (solid shape): outline of 139 points within 73.5,42.66 90.12,48.27
DGND on L10_SIG3 (solid shape): 107.99,98.42 108.1,98.44 108.16,98.35 108.16,94.99 108.01,94.83 107.94,94.8 107.87,94.83 107.59,94.92 107.33,94.79 107.24,94.76 107.16,94.81 106.44,94.71 107.11,94.4 107.2,94.44 107.27,94.38 107.3,94.33 107.33,94.29 107.36,94.22 107.33,94.15 101.62,88.45 100.61,88.45 100.51,88.51 100.54,88.62 102.81,90.89 102.82,90.91 102.88,90.95 102.95,90.95 103.43,91.17 103.24,91.66 103.18,91.73 103.21,91.82 105.25,93.86 105.25,95.68
DGND on L10_SIG3 (solid shape): outline of 145 points within 109.69,6.93 138.97,9.47
DGND on L10_SIG3 (solid shape): 167.35,101.96 167.58,101.73 167.6,101.72 167.61,101.66 167.56,101.63 167.48,101.63 167.23,101.38 167.19,101.37 167.16,101.38 167.14,101.4 167.02,101.52 166.9,101.6 166.76,101.63 166.22,101.63 165.99,101.4 165.97,101.38 165.94,101.36 165.9,101.38 165.88,101.4 165.76,101.52 165.64,101.6 165.5,101.63 164.96,101.63 164.73,101.4 164.71,101.38 164.68,101.36 164.64,101.38 164.62,101.4 164.5,101.52 164.38,101.6 164.24,101.63 163.7,101.63 163.52,101.45 163.45,101.42 163.37,101.46 163.08,101.6 162.79,101.47 162.71,101.43 162.63,101.47 162.49,101.57 162.31,101.6 162.23,101.62 162.2,101.7 162.2,101.92 162.64,102.36 162.72,102.39 162.8,102.35 163.08,102.17 163.4,102.29 163.47,102.32 163.66,102.21 163.8,102.18 164.34,102.18 164.57,102.41 164.65,102.53 164.68,102.67 164.68,102.77 167.35,102.77
DGND on L10_SIG3 (solid shape): 53.09,90.03 53.04,89.95 52.95,89.94 52.43,89.71 52.7,89.22 52.77,89.15 52.75,89.05 51.99,88.29 51.99,81.76 53.61,80.14 53.64,80.06 53.6,79.98 53.58,79.4 54.17,79.49 54.2,79.52 54.25,79.5 54.29,79.46 54.29,65.7 53.91,65.32 53.8,65.3 53.73,65.39 53.73,74.61 53,75.34 53,77.61 51.71,78.91 51.71,79.4 51.77,79.49 51.88,79.48 52.51,79.76 51.88,80.04 51.77,80.02 51.71,80.11 51.71,89.58 52.74,90.62 53.09,90.62
DGND on L10_SIG3 (solid shape): outline of 153 points within 139.68,58.71 147.15,64.68
DGND on L10_SIG3 (solid shape): outline of 147 points within 108.77,127.79 115.5,129.83
DGND on L10_SIG3 (solid shape): outline of 142 points within 185.46,100.55 187.63,103.54
DGND on L10_SIG3 (solid shape): outline of 164 points within 77.41,56.21 98.25,63.74
DGND on L10_SIG3 (solid shape): outline of 158 points within 101.35,125.25 115.5,127.92
DGND on L10_SIG3 (solid shape): outline of 162 points within 137.49,15.69 140.42,19.28
DGND on L10_SIG3 (solid shape): outline of 188 points within 106.3,118.72 113.15,124.56
DGND on L10_SIG3 (solid shape): outline of 181 points within 188.14,88.71 190.05,93.83
DGND on L10_SIG3 (solid shape): 183.9,102.93 183.94,102.95 183.97,102.93 184.11,102.79 184.23,102.71 184.38,102.69 184.82,102.69 184.9,102.64 184.93,102.23 185.21,102.08 185.25,102.06 185.27,102.03 185.27,101.99 185.25,101.95 185.21,101.94 184.88,101.61 185.21,101.28 185.25,101.26 185.27,101.23 185.27,101.19 185.25,101.15 185.21,101.14 184.97,101.03 184.88,100.78 184.88,100.75 184.83,100.7 184.74,100.79 184.74,100.81 184.5,101.12 184.13,100.98 184.06,100.94 183.97,100.96 183.87,101.07 183.76,101.14 183.64,101.17 183.6,101.19 183.6,101.26 183.64,101.28 183.89,101.78 183.33,101.78 183.26,101.74 183.17,101.76 183.07,101.87 182.92,101.96 182.75,101.97 182.73,101.97 182.34,102.35 182.34,102.38 182.34,102.46 182.31,102.54 182.32,102.63 182.39,102.69 182.62,102.92 182.64,102.93 182.68,102.95 182.71,102.93 182.85,102.79 182.97,102.71 183.12,102.69 183.65,102.69 183.88,102.92
DGND on L10_SIG3 (solid shape): outline of 210 points within 110.06,120.17 115.5,123.93
DGND on L10_SIG3 (solid shape): outline of 220 points within 143.47,132.05 161.96,138.34
DGND on L10_SIG3 (solid shape): outline of 220 points within 105.38,132.12 126.01,139.52
DGND on L10_SIG3 (solid shape): outline of 228 points within 116.6,53.49 135.31,66.68
DGND on L10_SIG3 (solid shape): 144.43,107.4 144.74,107.06 145.08,107.36 145.12,107.42 145.19,107.45 145.93,107.45 145.99,107.42 146.03,107.36 146.38,107.06 146.69,107.4 146.69,107.45 146.83,107.45 146.93,107.15 147.2,107.06 147.25,107.06 147.25,106.92 147.2,106.92 146.9,106.8 146.84,106.48 146.85,106.45 146.8,106.39 146.68,106.51 146.68,106.54 146.38,106.92 146.03,106.59 146.02,106.54 145.89,106.54 145.89,106.59 145.56,106.92 145.23,106.59 145.22,106.54 145.09,106.54 145.09,106.59 144.59,106.88 144.58,106.31 144.63,106.23 144.6,106.15 144.41,105.96 144.41,105.95 144.38,105.9 144.32,105.91 144.2,106.04 144.09,106.11 143.96,106.14 143.93,106.15 143.91,106.19 143.91,106.21 143.93,106.24 143.96,106.26 144.29,106.59 143.96,106.92 143.93,106.94 143.91,106.97 143.91,107.01 143.93,107.04 144.19,107.16 144.29,107.45 144.43,107.45
DGND on L10_SIG3 (solid shape): outline of 93 points within 62.41,82.4 93.42,85.66
DGND on L10_SIG3 (solid shape): outline of 260 points within 108.74,109.82 117.07,115.28
DGND on L10_SIG3 (solid shape): outline of 352 points within 55.41,92.52 80.82,94.73
DGND on L10_SIG3 (solid shape): outline of 366 points within 148.55,75.53 156.23,80.93
DGND on L10_SIG3 (solid shape): outline of 109 points within 130.38,118.85 151.21,120.4
DGND on L10_SIG3 (solid shape): outline of 430 points within 54.28,62.81 84.86,79.84
DGND on L10_SIG3 (solid shape): outline of 103 points within 56.32,87.27 90.82,90.31
DGND on L10_SIG3 (solid shape): outline of 479 points within 79.61,91.61 118.65,112.21
DGND on L10_SIG3 (solid shape): outline of 485 points within 78.15,68.84 115.63,85.79
DGND on L10_SIG3 (solid shape): outline of 113 points within 119.45,105.75 149.6,112.81
DGND on L10_SIG3 (solid shape): outline of 549 points within 118.78,89.5 130.71,101.89
DGND on L10_SIG3 (solid shape): outline of 599 points within 53.72,78.47 72.64,88.65
DGND on L10_SIG3 (solid shape): outline of 590 points within 153.51,93.74 156.11,103.26
DGND on L10_SIG3 (solid shape): outline of 814 points within 34.58,106.7 78.78,114.72
DGND on L10_SIG3 (solid shape): outline of 724 points within 138.48,88.02 141.62,96.81
DGND on L10_SIG3 (solid shape): outline of 845 points within 98.06,65.04 130.08,93.07
DGND on L10_SIG3 (solid shape): outline of 864 points within 128.77,98.26 142.44,104.66
DGND on L10_SIG3 (solid shape): outline of 931 points within 148.46,95.64 152.82,102.65
DGND on L10_SIG3 (solid shape): outline of 920 points within 32.22,104.8 49.69,127.67
DGND on L10_SIG3 (solid shape): outline of 1119 points within 115.76,97.83 143.21,109.03
DGND on L10_SIG3 (solid shape): outline of 1327 points within 23.56,98.18 59.68,133.02
DGND on L10_SIG3 (solid shape): outline of 1388 points within 119.54,53.49 176.93,78.46
DGND on L10_SIG3 (solid shape): outline of 1722 points within 58.39,123.73 152.43,139.22
DGND on L10_SIG3 (solid shape): outline of 2474 points within 142.31,87.39 149.2,105.05
DGND on L10_SIG3 (solid shape): outline of 2515 points within 147.84,75.53 166.15,94.87
DGND on L10_SIG3 (solid shape): outline of 3474 points within 39.86,80.64 104.31,115.63
DGND on L10_SIG3 (solid shape): outline of 3422 points within 72.47,9.54 118.34,68.14
DGND on L10_SIG3 (solid shape): outline of 4503 points within 137.49,6.69 201.74,42.19
DGND on L10_SIG3 (solid shape): outline of 4988 points within 148.02,32.83 179.45,73.48
DGND on L10_SIG3 (solid shape): outline of 14399 points within 142.73,31.34 202.08,147.22
DGND on L10_SIG3 (solid shape): outline of 39164 points within 7.51,0.52 209.66,177.28
DGND on L12_SIG4 (solid shape): 122.88,96.82 121.73,96.82 121.22,96.3 121.18,96.3 121.09,96.36 121.11,96.47 121.91,97.27 122.88,97.27
DGND on L12_SIG4 (solid shape): 181.19,114.02 181.19,113.33 180.94,113.07 177.27,113.07 177.17,113.14 177.19,113.25 177.23,113.28 180.25,113.28 181.09,114.12
DGND on L12_SIG4 (solid shape): 141.91,38.37 141.91,36.73 140.71,35.54 140.71,35.51 140.65,35.49 139.68,36.45 137.81,36.45 135.71,38.56 135.68,38.67 135.78,38.73 141.55,38.73
DGND on L12_SIG4 (solid shape): 33.83,109.26 33.9,109.36 34.01,109.33 37.03,106.31 37.03,106.19 36.97,106.09 36.86,106.12 33.83,109.14
DGND on L12_SIG4 (solid shape): 43.21,128.24 43.26,128.21 43.25,128.16 43.16,128.07 35.51,128.07 32.61,125.17 32.5,125.15 32.44,125.25 32.44,125.68 35,128.24
DGND on L12_SIG4 (solid shape): 90.11,59.06 90.21,58.99 90.19,58.88 90.05,58.75 85.33,58.75 85.24,58.81 85.26,58.92 85.4,59.06
DGND on L12_SIG4 (solid shape): 105.49,47.89 105.59,47.83 105.56,47.71 89.6,31.75 89.12,31.75 89.02,31.81 89.04,31.92 105.01,47.89
DGND on L12_SIG4 (solid shape): 144.2,53.09 144.31,53.11 144.37,53.02 144.37,50.21 144.03,49.87 143.92,49.85 143.86,49.94 143.86,52.75
DGND on L12_SIG4 (solid shape): 168.59,128.83 168.64,128.8 168.63,128.75 157.1,117.22 157.1,116.88 156.74,116.53 156.63,116.5 156.57,116.6 156.57,116.91 168.49,128.83
DGND on L12_SIG4 (solid shape): 106.79,47.58 106.89,47.52 106.86,47.41 90.2,30.75 85.31,30.75 85.18,30.88 85.15,30.99 85.25,31.06 89.89,31.06 106.41,47.58
DGND on L12_SIG4 (solid shape): 86.93,56.35 87.05,56.22 87.07,56.11 86.98,56.05 86.72,56.05 86.02,56.75 85.33,56.75 85.24,56.81 85.26,56.92 85.33,56.99 86.93,56.99
DGND on L12_SIG4 (solid shape): 141.8,145.14 141.91,145.16 141.97,145.07 141.97,133.25 141.65,132.93 141.58,132.9 141.51,132.93 141.44,132.99 141.37,133.03 141.34,133.04 141.34,144.69
DGND on L12_SIG4 (solid shape): 93.88,63.69 93.98,63.62 93.95,63.51 93.56,63.12 88.68,63.12 88.46,63.35 88.46,63.36 88.41,63.44 88.35,63.51 88.32,63.62 88.41,63.69
DGND on L12_SIG4 (solid shape): 131.31,129.58 131.42,129.6 131.49,129.51 131.49,115.31 130.91,114.73 130.91,108.91 135.01,104.82 135.03,104.71 134.94,104.65 132.22,104.65 130.59,106.28 130.59,110.64 129.34,111.9 129.34,127.6
DGND on L12_SIG4 (solid shape): 160.99,109.11 161.09,109.05 161.07,108.94 159.89,107.76 159.15,107.76 159.1,107.78 159.1,107.83 159.14,107.97 159.13,108.11 159.13,108.12 159.13,109.05 159.2,109.11
DGND on L12_SIG4 (solid shape): 108.07,74.7 108.18,74.73 108.24,74.64 108.27,74.51 108.34,74.4 108.37,74.33 108.34,74.25 105.44,71.35 104.51,71.35 91.36,58.21 90.74,58.21 90.64,58.27 90.66,58.38 104.22,71.94 105.3,71.94
DGND on L12_SIG4 (solid shape): 123.33,61.66 123.44,61.68 123.5,61.59 123.5,60.35 118.39,55.24 117.89,55.24 117.08,54.42 117.08,53.93 115.87,52.72 114.84,52.72 112.96,50.84 108.83,50.84 108.75,50.87 108.72,50.95 108.73,50.99 108.75,51.06 108.83,51.09 112.76,51.09
DGND on L12_SIG4 (solid shape): 145.81,117.25 145.92,117.27 145.98,117.18 145.98,115.74 145.4,115.16 145.4,113.7 145.34,113.61 145.24,113.61 145.14,113.66 145.03,113.67 144.99,113.69 144.97,113.73 144.97,113.76 144.97,115.53 145.6,116.15 145.6,117.04
DGND on L12_SIG4 (solid shape): 136.56,139.11 136.62,139.02 136.62,136.24 128.37,128 128.37,111.5 129.63,110.25 129.63,105.88 131.51,104 131.6,103.91 131.61,103.85 131.56,103.82 130.04,103.82 127.29,106.57 127.29,127.29 136.09,136.09 136.09,138.95 136.11,138.99 136.14,139 136.31,139.03 136.46,139.1
DGND on L12_SIG4 (solid shape): 176.37,83.45 176.39,83.34 176.3,83.28 174.54,83.28 174.3,83.53 174.96,84.19 174.96,84.67 174.58,85.05 174.46,85.13 174.32,85.16 174.07,85.16 174.07,85.56 173.69,85.94 173.57,86.02 173.43,86.05 173.1,86.05 172.44,85.38 171.82,86.01 171.79,86.12 171.89,86.18 172.35,86.18 173,86.83
DGND on L12_SIG4 (solid shape): 148.56,57.96 148.61,57.87 148.61,57.85 148.56,57.77 148.47,57.76 148.32,57.78 148.18,57.75 148.17,57.75 147.11,57.75 142.15,52.79 142.15,49.94 141.89,49.69 141.78,49.66 141.72,49.76 141.72,52.52 147.17,57.97 148.17,57.97 148.17,57.97 148.32,57.94 148.47,57.97
DGND on L12_SIG4 (solid shape): 122.06,92.06 122.13,92.03 122.16,91.96 122.33,91.63 122.7,91.6 122.79,91.59 122.84,91.51 122.84,90.84 122.88,90.81 122.89,90.75 122.84,90.72 122.09,90.72 121.77,90.39 121.66,90.37 121.59,90.47 121.59,92.06
DGND on L12_SIG4 (solid shape): 152.8,94.83 152.8,94.17 152.78,94.14 152.75,94.12 152.53,94.03 152.43,93.81 152.42,93.76 152.21,93.76 152.11,93.66 152,93.64 151.93,93.73 151.93,94.03 151.87,94.09 151.85,94.2 151.95,94.26 152.2,94.36 152.28,94.62 152.28,94.65 152.63,95
DGND on L12_SIG4 (solid shape): 157.1,35.75 157.19,35.7 157.2,35.6 157.17,35.52 157.16,35.43 157.13,35.35 157.05,35.32 155.99,35.32 155.44,34.77 155.43,34.77 155.24,34.6 155.2,34.35 155.18,34.27 155.1,34.23 154.91,34.23 154.49,34.64 154.47,34.74 154.54,34.81 154.69,34.9 154.79,35.04 154.79,35.05 155.49,35.75
DGND on L12_SIG4 (solid shape): 182.66,135.89 182.77,135.91 182.83,135.82 182.83,135.58 182.88,135.53 182.83,135.48 182.81,135.48 182.43,135.07 182.86,134.73 182.94,134.7 182.98,134.63 182.98,130.28 182.94,130.24 182.83,130.22 182.77,130.32 182.77,134.05 182.32,134.5 182.32,135.55
DGND on L12_SIG4 (solid shape): 170.48,58.91 170.54,59.01 170.65,58.98 172.5,57.13 172.5,51.8 173.11,51.19 173.11,46.86 173.07,46.78 172.97,46.76 172.73,46.77 172.54,46.63 172.45,46.58 172.37,46.63 172.17,46.77 171.92,46.76 171.82,46.77 171.78,46.85 171.78,54.3 171.48,54.59 171.48,57.72 170.48,58.73
DGND on L12_SIG4 (solid shape): 114.57,51.47 114.66,51.5 114.73,51.45 114.85,51.33 115.01,51.27 115.09,51.2 115.07,51.1 114.47,50.5 113.85,50.5 113.15,49.8 103.66,49.8 103.57,49.86 103.59,49.97 103.76,50.14 104.75,50.14 104.87,50.26 105.32,50.22 105.49,50.63 105.51,50.72 105.59,50.76 107.22,50.76 107.84,50.14 113.24,50.14
DGND on L12_SIG4 (solid shape): 143.72,39.34 143.78,39.43 143.89,39.41 146.07,37.23 146.07,36.7 143.72,36.7 143.72,37.57 143.78,37.66 143.9,37.63 144.57,37.87 143.9,38.12 143.78,38.09 143.72,38.18
DGND on L12_SIG4 (solid shape): 153.25,62.35 153.26,62.36 153.28,62.37 153.31,62.38 153.34,62.38 153.37,62.36 153.39,62.35 153.41,62.32 153.42,62.29 153.42,62.28 153.42,55.92 152,54.5 151.99,54.49 151.96,54.48 151.93,54.47 151.9,54.48 151.88,54.49 151.85,54.51 151.84,54.53 151.83,54.56 151.83,54.58 151.83,56.16 151.95,56.16 151.96,56.1 151.97,56.05 151.99,55.99 152.02,55.95 152.05,55.9 152.09,55.86 152.14,55.83 152.19,55.81 152.24,55.79 152.29,55.78 152.35,55.78 152.41,55.78 152.46,55.8 152.51,55.82 152.56,55.85 152.6,55.88 152.64,55.92 152.67,55.97 152.69,56.02 152.71,56.07 152.72,56.13 152.72,56.18 152.71,56.24 152.69,56.29 152.67,56.34 152.64,56.39 152.6,56.43 152.56,56.47 152.51,56.5 152.46,56.52 152.41,56.53 152.35,56.54 152.29,56.54 152.24,56.53 152.19,56.51 152.14,56.48 152.09,56.45 152.05,56.41 152.02,56.37 151.99,56.32 151.97,56.27 151.96,56.21 151.95,56.16 151.83,56.16 151.83,60.93
DGND on L12_SIG4 (solid shape): 179.83,110.46 179.92,110.39 179.9,110.28 174.83,105.22 174.75,105.1 174.72,104.96 174.72,104.53 174.39,104.53 174.01,104.14 173.93,104.03 173.9,103.88 173.9,103.68 173.88,103.65 173.84,103.63 173.82,103.63 173.5,103.63 173.12,103.25 173.04,103.13 173.01,102.99 173.01,102.74 172.61,102.74 172.26,102.4 168.95,102.4 168.86,102.46 168.88,102.57 169.63,103.32 172.66,103.32 175.06,105.73 175.06,106.39 175.73,106.39 176.25,106.91 176.25,107.58 176.91,107.58 177.43,108.1 177.43,108.76 178.1,108.76 178.62,109.28 178.62,109.95 179.28,109.95 179.79,110.46
DGND on L12_SIG4 (solid shape): 168.87,104.14 168.97,104.08 168.94,103.97 167.35,102.37 163.59,102.37 163.52,102.41 163.49,102.49 163.12,102.93 162.74,102.49 162.72,102.41 162.64,102.37 162.22,102.37 162.13,102.43 162.15,102.54 163.71,104.11 163.81,104.02 165.88,104.02 166.22,103.68 166.34,103.6 166.48,103.57 166.91,103.57 167.48,104.14
DGND on L12_SIG4 (solid shape): 178.75,89.1 178.81,89.2 178.92,89.17 179.29,88.81 180.89,88.81 181.25,88.44 181.25,88.27 181.24,88.24 181.2,88.22 180.88,87.89 181.2,87.56 181.24,87.54 181.24,87.47 181.2,87.46 181.03,87.41 180.9,87.28 180.81,87.23 180.72,87.28 180.59,87.41 180.41,87.46 178.76,87.46 178.75,87.47
DGND on L12_SIG4 (solid shape): 170.91,93.44 170.99,93.41 171.41,92.99 171.41,89.99 171.35,89.9 171.24,89.92 170.32,90.84 170.32,92.24 170.36,92.32 170.45,92.34 170.93,92.71 170.45,93.08 170.36,93.1 170.32,93.18 170.32,93.18 170.36,93.26 170.45,93.28 170.66,93.29 170.84,93.4
DGND on L12_SIG4 (solid shape): 169.38,92.91 169.38,90.45 170.56,89.27 169.91,88.62 169.91,88.16 169.91,88.14 169.9,88.12 169.88,88.09 169.86,88.07 169.83,88.06 169.8,88.06 169.77,88.06 169.75,88.08 169.74,88.09 167.99,89.84 167.99,90.84 167,91.83 168.4,91.83 168.41,91.78 168.42,91.72 168.44,91.67 168.46,91.62 168.5,91.58 168.54,91.54 168.58,91.51 168.63,91.48 168.69,91.46 168.74,91.45 168.8,91.45 168.85,91.46 168.91,91.47 168.96,91.49 169,91.52 169.05,91.56 169.08,91.6 169.12,91.65 169.14,91.7 169.16,91.75 169.16,91.8 169.16,91.86 169.16,91.92 169.14,91.97 169.12,92.02 169.08,92.07 169.05,92.11 169,92.14 168.96,92.17 168.91,92.19 168.85,92.21 168.8,92.21 168.74,92.21 168.69,92.2 168.63,92.18 168.58,92.16 168.54,92.13 168.5,92.09 168.46,92.04 168.44,91.99 168.42,91.94 168.41,91.89 168.4,91.83 167,91.83 166,92.83 165.77,92.83 165.76,92.83 165.73,92.84 165.7,92.85 165.68,92.88 165.67,92.91 165.67,92.95 165.66,93 165.65,93.06 165.65,93.09 165.66,93.12 165.68,93.14 165.71,93.15 165.75,93.16 169.14,93.16
DGND on L12_SIG4 (solid shape): 142.76,81.8 142.84,81.82 142.92,81.78 143.08,81.63 143.3,81.6 143.38,81.58 143.42,81.5 143.42,80.17 143.39,80.1 143.31,80.07 142.93,79.69 143.31,79.31 143.39,79.28 143.42,79.21 143.42,78.72 142.85,78.15 142.85,73.74 142.81,73.67 142.73,73.64 142.66,73.65 142.59,73.63 142.5,73.65 142.46,73.73 142.46,79.39 142.61,79.54 142.61,81.65
DGND on L12_SIG4 (solid shape): 150.67,30.21 150.74,30.3 150.85,30.28 152.57,28.56 151.93,27.92 151.93,27.18 152.48,26.63 153.22,26.63 153.86,27.27 155.23,25.9 155.91,25.9 155.91,25.22 156.46,24.67 157.13,24.67 157.13,24 158.05,23.08 158.05,17.85 158.01,17.77 157.92,17.76 157.41,17.4 157.92,17.04 158.01,17.03 158.05,16.94 158.05,15.02 154.75,11.72 154.63,11.7 154.57,11.79 154.57,12.44 156.77,14.64 156.77,21.95 154.87,23.85 154.19,23.85 154.19,24.52 153.64,25.07 152.97,25.07 152.97,25.75 150.67,28.04
DGND on L12_SIG4 (solid shape): outline of 88 points within 153.54,17.74 160.04,29
DGND on L12_SIG4 (solid shape): 122.27,79.31 122.32,79.35 122.39,79.34 122.45,79.32 122.51,79.31 122.6,79.25 122.58,79.14 113.27,69.83 111.3,69.83 111.22,69.87 111.2,69.96 110.84,70.46 110.48,69.96 110.46,69.87 110.38,69.83 109.63,69.83 109.54,69.89 109.56,70 111.44,71.88 111.51,71.91 111.58,71.88 111.92,71.79 112.19,72.02 112.19,72.03 112.28,72.12 113.71,72.12 113.98,72.39 115.35,72.39 122.25,79.3
DGND on L12_SIG4 (solid shape): outline of 99 points within 106.26,71.05 120.1,84.89
DGND on L12_SIG4 (solid shape): 159.52,17.04 159.57,16.95 159.57,14.05 159.09,13.58 159.09,11.31 159.08,11.28 159.04,11.26 158.85,11.23 158.68,11.12 158.61,11.09 158.54,11.12 158.21,11.26 157.86,11.16 157.79,11.18 157.72,11.19 157.61,11.19 157.6,11.2 157.28,11.26 156.98,11.13 156.91,11.1 156.49,11.26 156.14,11.13 156.05,11.16 155.96,11.18 155.94,11.18 155.88,11.21 155.83,11.23 155.76,11.31 155.79,11.4 159.01,14.63 159.01,16.95 159.06,17.03 159.15,17.04 159.29,17.02 159.43,17.05
DGND on L12_SIG4 (solid shape): 181.38,138.37 181.32,138.31 181.21,138.31 180.94,138.19 180.86,137.9 180.86,137.88 180.45,137.47 180.45,136.27 180.67,136.05 180.67,135.65 180.63,135.56 180.54,135.55 180.03,135.19 180.54,134.83 180.63,134.82 180.67,134.74 180.67,129.57 180.45,129.35 180.45,128.62 180.44,128.58 180.4,128.57 180.08,128.24 180.4,127.91 180.44,127.89 180.45,127.86 180.45,126.77 179.88,126.2 179.77,126.18 179.71,126.27 179.71,137.7 180.6,138.59 181.38,138.59
DGND on L12_SIG4 (solid shape): outline of 111 points within 32.99,120.63 37.59,127.38
DGND on L12_SIG4 (solid shape): 183.28,109.7 183.38,109.48 183.6,109.39 183.64,109.38 183.65,109.34 183.65,108.4 183.25,108 183.18,107.97 183.1,108 182.67,108.11 182.43,107.73 182.4,107.65 182.33,107.62 181.77,107.62 180.4,106.25 180.29,106.23 180.23,106.32 180.23,107.28 180.27,107.36 180.35,107.38 180.73,107.56 180.72,107.98 180.71,108.09 180.8,108.14 182.43,108.14 182.77,108.48 182.77,109.3 182.78,109.34 182.82,109.35 183.07,109.46 183.18,109.7 183.18,109.74 183.28,109.74
DGND on L12_SIG4 (solid shape): 156.37,129.7 156.44,129.8 156.56,129.75 156.78,129.47 157.08,129.29 157.13,129.22 157.13,119.32 155.21,117.39 155.1,117.37 155.03,117.46 155.03,117.65 155.07,117.73 155.15,117.76 155.58,118.13 155.15,118.51 155.07,118.54 155.03,118.61 155.03,120.52 155.08,120.61 155.17,120.62 155.69,121.01 155.11,121.3 155.06,121.29 155.03,121.34 155.03,121.42 155.59,121.98 155.59,127.62 156.37,128.39
DGND on L12_SIG4 (solid shape): 157.23,102.58 157.56,102.26 157.89,102.58 157.89,102.63 158.82,102.63 158.83,102.58 158.85,102.47 158.9,102.38 158.93,102.31 158.9,102.24 158.71,102.05 158.64,102.02 158.57,102.04 158.23,102.09 158.03,101.81 158.02,101.77 157.89,101.77 157.88,101.81 157.54,102.12 157.23,101.78 157.23,101.75 157.13,101.66 157.08,101.71 157.08,101.74 157.01,102 156.78,102.12 156.74,102.14 156.73,102.17 156.73,102.21 156.74,102.24 156.99,102.36 157.09,102.58 157.09,102.63 157.22,102.63
DGND on L12_SIG4 (solid shape): outline of 137 points within 140.8,124.32 154.21,142.65
DGND on L12_SIG4 (solid shape): outline of 153 points within 32.94,71.61 37.44,80.6
DGND on L12_SIG4 (solid shape): 141.95,119.52 142.01,119.61 142.13,119.59 142.22,119.5 142.24,119.46 142.28,119.43 143.04,118.68 143.04,118.07 143,117.99 142.91,117.97 142.43,117.6 142.91,117.23 143,117.22 143.04,117.14 143.04,117.07 143,116.99 142.91,116.97 142.46,116.74 142.64,116.26 142.68,116.21 142.69,116.14 142.68,116.12 142.68,114.39 142.87,114.21 142.9,114.19 142.94,114.18 143.01,114.15 143.04,114.08 143.04,111.27 142.66,110.89 142.55,110.87 142.49,110.97 142.49,112.46 142.49,112.48 142.49,112.55 142.54,112.6 142.75,113.01 142.4,113.32 142.37,113.34 142.35,113.37 142.35,114.04 141.7,114.7 141.7,117.71 141.95,117.97
DGND on L12_SIG4 (solid shape): outline of 151 points within 171.78,36.79 176.18,45.77
DGND on L12_SIG4 (solid shape): outline of 176 points within 116.45,47.97 135.53,67.03
DGND on L12_SIG4 (solid shape): outline of 175 points within 147.7,101.68 151.18,103.42
DGND on L12_SIG4 (solid shape): outline of 224 points within 104.3,52.7 115.54,56.28
DGND on L12_SIG4 (solid shape): 179.15,114.15 179.95,114.15 180,114.12 179.99,114.07 179.94,114.02 176.93,114.02 176.77,113.86 176.33,113.86 171.34,108.86 171.34,108.78 171.28,108.79 170.82,108.41 171.28,108.04 171.34,108.04 171.34,107.9 171.28,107.9 170.91,107.76 170.85,107.38 170.84,107.28 170.76,107.24 170.63,107.24 170.55,107.28 170.54,107.38 170.18,107.89 169.82,107.38 169.81,107.28 169.73,107.24 169.22,107.24 169.12,107.3 169.15,107.41 169.89,108.15 169.92,108.12 170.56,108.34 170.02,108.75 169.93,108.75 169.88,108.84 169.88,108.92 169.94,108.92 169.95,108.92 170.33,109.03 170.41,109.42 170.41,109.43 170.41,109.49 170.46,109.49 170.54,109.45 170.56,109.38 171.01,108.97 171.29,109.51 171.27,109.54 175.89,114.15 177.16,114.15 177.3,114.18 177.42,114.26 177.56,114.41 177.6,114.42 177.64,114.41 177.66,114.38 177.89,114.15 178.42,114.15 178.56,114.18 178.68,114.26 178.86,114.44
DGND on L12_SIG4 (solid shape): 189.2,124.77 189.4,124.74 189.58,124.63 189.61,124.61 189.65,124.63 189.77,124.71 189.91,124.76 190,124.74 190.03,124.66 190.03,124.62 190.02,124.58 189.99,124.57 189.68,124.24 189.99,123.91 190.02,123.89 190.03,123.86 190.03,123.82 190.02,123.78 189.99,123.77 189.69,123.53 189.81,123.17 189.81,117.63 189.71,117.53 189.64,117.5 189.56,117.53 189.01,117.55 189.03,116.99 189.06,116.92 189.03,116.85 188.82,116.64 188.4,116.64 187.35,115.58 187.31,115.54 187.28,115.48 187.19,115.43 187.1,115.48 186.82,115.65 186.53,115.5 186.46,115.45 186.37,115.48 185.73,116.12 186.07,116.46 187.55,116.46 188.78,117.68 188.78,118.86 188.84,118.95 188.95,118.93 189.54,118.96 189.4,119.53 189.34,119.61 189.37,119.69 189.39,119.71 189.39,122.83 189.26,122.95 189.24,123.05 189.31,123.12 189.54,123.48 189.22,123.77 189.19,123.78 189.17,123.82 189.17,123.86 189.19,123.89 189.22,123.91 189.54,124.24 189.22,124.57 189.19,124.58 189.17,124.62 189.17,124.68 189.13,124.72 189.18,124.77
DGND on L12_SIG4 (solid shape): outline of 291 points within 148.42,9.93 155.81,31.44
DGND on L12_SIG4 (solid shape): outline of 279 points within 120.46,105.65 122.67,124.85
DGND on L12_SIG4 (solid shape): outline of 337 points within 145.46,44.18 148.61,53.71
DGND on L12_SIG4 (solid shape): outline of 333 points within 150.94,9.83 164.22,36.06
DGND on L12_SIG4 (solid shape): outline of 344 points within 151.94,92.11 155.83,95.26
DGND on L12_SIG4 (solid shape): outline of 418 points within 101.74,60.63 118.18,67.45
DGND on L12_SIG4 (solid shape): outline of 388 points within 187.57,88.85 190.03,97.34
DGND on L12_SIG4 (solid shape): outline of 504 points within 147.7,111.39 154.29,131.93
DGND on L12_SIG4 (solid shape): outline of 608 points within 152.58,45.32 168.1,70.49
DGND on L12_SIG4 (solid shape): outline of 600 points within 143.91,95.25 149.64,100.21
DGND on L12_SIG4 (solid shape): outline of 582 points within 131.88,105.08 138.99,142.67
DGND on L12_SIG4 (solid shape): outline of 621 points within 131.73,106.01 141.61,155.19
DGND on L12_SIG4 (solid shape): outline of 99 points within 15.71,83.91 35.34,91.42
DGND on L12_SIG4 (solid shape): outline of 628 points within 186.04,102.23 190.03,111.06
DGND on L12_SIG4 (solid shape): outline of 696 points within 155.92,71.24 162.21,88.67
DGND on L12_SIG4 (solid shape): outline of 831 points within 185.73,127.7 190.03,138.49
DGND on L12_SIG4 (solid shape): outline of 814 points within 151.11,95.98 155.31,107.87
DGND on L12_SIG4 (solid shape): outline of 977 points within 85.07,29.61 146.6,66.72
DGND on L12_SIG4 (solid shape): outline of 1372 points within 152.58,35.74 163.32,56.5
DGND on L12_SIG4 (solid shape): outline of 1484 points within 141.87,101.77 147.39,112.69
DGND on L12_SIG4 (solid shape): outline of 1642 points within 144.76,58.66 155.38,91.26
DGND on L12_SIG4 (solid shape): outline of 1764 points within 138.55,113.32 161.54,155.19
DGND on L12_SIG4 (solid shape): outline of 1949 points within 163.62,108.74 188.65,138.49
DGND on L12_SIG4 (solid shape): outline of 2829 points within 73.46,29.61 101.77,63.69
DGND on L12_SIG4 (solid shape): outline of 3873 points within 112.67,88.02 143.32,136.78
DGND on L12_SIG4 (solid shape): outline of 76385 points within 7.51,0.52 209.66,177.28
DGND on L02_GND1: 7.51,147.38 7.51,153.8 7.76,154.05 9.12,154.05 10.95,155.88 11.96,155.88 12.24,156.16 12.24,158.01 12.07,158.19 10.49,158.19 10.39,158.29 10.39,161.09 10.57,161.26 12.27,161.26 12.67,161.67 12.67,165.2 12.22,165.66 7.77,165.66 7.51,165.93 7.51,177.28 209.66,177.28 209.66,0.52 109,0.52 108.79,0.74 108.79,2.57 107.24,4.11 107.24,5 107.04,5.21 105.13,5.21 104.98,5.05 104.98,3.56 104.85,3.43 102.01,3.43 101.9,3.53 101.9,5.11 101.8,5.21 99.82,5.21 99.69,5.08 99.69,3.86 98.88,3.05 97.79,3.05 97.21,2.46 97.21,0.85 96.88,0.52 7.51,0.52 7.51,135.06 7.8,135.36 11.94,135.36 12.29,135.71 12.29,139.14 12,139.43 10.59,139.43 10.4,139.62 10.4,142.32 10.56,142.48 11.99,142.48 12.29,142.79 12.29,146.28 11.89,146.69 8.2,146.69 ; 9 cut-outs
DGND on L04_GND2: 7.51,165.89 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.52 102.04,0.52 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,153.67 7.73,153.9 8.97,153.9 10.95,155.88 11.96,155.88 12.24,156.16 12.24,157.99 12.04,158.19 10.49,158.19 10.39,158.29 10.39,161.06 10.57,161.24 12.27,161.24 12.67,161.65 12.67,165.2 12.22,165.66 7.74,165.66 ; 3 cut-outs
DGND on L06_PWR1: 155.92,110.11 152.78,106.97 152.78,99.44 155.32,96.9 155.32,92.46 167.13,92.46 168.78,90.81 168.78,85.34 171.32,82.8 171.32,80.14 177.8,73.66 189.48,73.66 194.95,79.12 194.95,145.67 193.29,147.32 185.55,147.32 181.48,143.26 181.48,109.47 180.34,108.33 175.51,108.33 173.99,106.81 169.76,106.81 169.27,107.3 169.27,109.39 168.56,110.11
DGND on L08_PWR3: 99.59,1.03 8.01,1.03 8.01,123.51 8.41,123.9 30.38,123.9 34.95,128.47 34.95,144.58 32.05,147.47 15.24,147.47 13.18,145.41 12.6,145.41 12.4,145.62 12.4,146.2 11.89,146.71 8.29,146.71 8.01,146.99 8.01,155.94 8.6,155.94 10.06,157.39 8.6,158.84 8.01,158.84 8.01,160.69 8.6,160.69 10.06,162.14 8.6,163.59 8.01,163.59 8.01,176.77 209.16,176.77 209.16,1.03 107.3,1.03 107.3,1.6 105.82,3.08 104.34,1.6 104.34,1.03 102.55,1.03 102.55,1.6 101.07,3.08 99.59,1.6 ; 20 cut-outs
DGND on L09_GND3: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,156.45 8.6,156.45 9.55,157.39 8.6,158.34 7.51,158.34 7.51,161.2 8.6,161.2 9.55,162.14 8.6,163.09 7.51,163.09 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.72 104.65,0.52 102.23,0.52 102.04,0.72 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 3 cut-outs
DGND on L11_GND4: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,156.45 8.6,156.45 9.55,157.39 8.6,158.34 7.51,158.34 7.51,161.2 8.6,161.2 9.55,162.14 8.6,163.09 7.51,163.09 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.71 104.66,0.52 102.23,0.52 102.04,0.72 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 3 cut-outs
DGND on L13_GND5: 7.51,139.57 7.51,142.37 8.58,142.37 9.56,143.34 8.58,144.32 7.51,144.32 7.51,156.45 8.6,156.45 9.55,157.39 8.6,158.34 7.51,158.34 7.51,161.2 8.6,161.2 9.55,162.14 8.6,163.09 7.51,163.09 7.51,177.28 209.66,177.28 209.66,0.52 106.79,0.52 106.79,1.6 105.82,2.57 104.85,1.6 104.85,0.72 104.65,0.52 102.23,0.52 102.04,0.72 102.04,1.6 101.07,2.57 100.1,1.6 100.1,0.52 7.51,0.52 7.51,137.62 8.58,137.62 9.56,138.6 8.58,139.57 ; 8 cut-outs
GNDUSB on TOP: 7.62,136.02 7.62,142.37 7.67,142.37 7.7,142.39 7.7,144.3 7.49,144.5 7.49,146.15 7.65,146.3 11.43,146.3 11.81,145.92 11.81,142.62 10.29,142.62 10.29,139.32 10.92,139.32 10.92,137.29 9.4,135.76 7.87,135.76
GNDUSB on BOTTOM: 7.62,146.08 7.95,146.41 11.15,146.41 11.33,146.23 11.33,139.62 10.67,138.97 10.67,137.33 9.21,135.86 7.9,135.86 7.62,136.14
GNDUSB on L02_GND1: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.43,146.3 11.81,145.92 11.81,143.03 11.66,142.88 10.41,142.88 10.01,142.47 10.01,139.47 10.44,139.04 11.66,139.04 11.81,138.89 11.81,135.97 11.61,135.76
GNDUSB on L04_GND2, L05_SIG2, L08_PWR3, L11_GND4: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.36 9.3,135.76
GNDUSB on L09_GND3: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,146.08 11.33,139.62 10.9,139.19 10.9,137.36 9.3,135.76
GNDUSB on L10_SIG3: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.36 9.3,135.76
GNDUSB on L12_SIG4: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.37 9.29,135.76
GNDUSB on L13_GND5: 7.72,135.76 7.49,135.99 7.49,137.43 7.7,137.64 8.58,137.64 9.54,138.6 8.58,139.55 7.7,139.55 7.49,139.76 7.49,142.18 7.7,142.39 8.58,142.39 9.54,143.34 8.58,144.3 7.7,144.3 7.49,144.51 7.49,146.13 7.67,146.3 11.13,146.3 11.33,146.1 11.33,139.62 10.9,139.19 10.9,137.52 9.14,135.76
VCC1V1 on BOTTOM: 132.36,158.47 132.36,165.66 131.98,166.04 124.97,166.04 124.97,172.33 126.51,172.33 126.51,170.08 127.56,169.04 136.58,169.04 136.58,166.17 137.26,166.17 137.26,163.02 145.57,163.02 145.57,169.1 149.48,169.1 149.48,158.47
VCC1V1 on L12_SIG4: 146.13,157.84 132.41,157.84 132.41,167.92 136.75,167.92 136.75,163.07 145.57,163.07 145.57,164.52 149.48,164.52 149.48,158.34 146.13,158.34
VCC1V2_DDR on BOTTOM: 165.35,153.54 165.35,159.07 167.13,159.07 167.13,166.32 170.37,166.32 170.37,166.31 174.94,166.31 174.94,153.54
VCC1V8 on TOP: 184.66,69.98 184.66,66.17 190.25,66.17 190.25,69.98
VCC1V8 on TOP: 167.39,18.8 167.39,13.34 169.1,13.34 169.1,18.8
VCC1V8 on TOP: 43.69,74.55 43.69,68.96 45.21,68.96 45.21,74.55
